# IAR project uEZGUI_StartHere.ewp, settings and files
configuration Debug (ARM, debug)
  General.CoreVariant: 39
  General.FPU2: 4
  General.OGChipSelectEditMenu: LPC4088 NXP LPC4088
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.IExtraOptions: --no_unaligned_access; --enum_is_int
  ICCARM.CCIncludePath2: .; ../../../Source/App/; ../../../../uEZ; ../../../../uEZ/Include; ../../../../uEZ/Source/Platform/FDI/uEZGUI_4088_43WQN; ../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx; ../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx/IAR/include; ../../../../uEZ/Source/RTOS/freertos/portable/IAR/ARM_CM4F; ../../../../uEZ/Source/RTOS/freertos/include; ../../../../uEZ/Source/Library/lwIP/src/include; ../../../../uEZ/Source/Library/lwIP/src; ../../../../uEZ/Source/Library/lwIP/Include; ../../../../uEZ/Source/Library/lwIP/src/include/ipv4; ../../../../uEZ/Source/Library/GUI/SEGGER/emWin; ../../../../uEZ/Source/Platform/emWin/Inc; ../../../../uEZ/Source/Platform/emWin/Config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uEZGUI_StartHere.hex
  ILINK.IlinkOutputFile: uEZGUI_4088_43WQN.out
  ILINK.IlinkIcfFile: uEZGUI_StartHere.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: ../../../../uEZ; ../../../../uEZ/Build/uEZGUI_4088_43WQN/IAR; ../../../../uEZ/Source/App/Demos/uEZGUI; ../../../../uEZ/Source/App/Demos/FDI/SEGGER/emWin/GUIDEMO; ../../../../uEZ/Source/Platform/FDI/uEZGUI_4088_43WQN; ../../../../uEZ/Source/Platform/emWin/; ../../../../uEZ/Source/Platform/emWin/Config; ../../../../uEZ/Source/Platform/emWin/Inc; ../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx; ../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx/IAR/include; ../../../../uEZ/Source/RTOS/freertos/portable/IAR/ARM_CM4F; ../../../../uEZ/Source/RTOS/freertos/include; ../../../../uEZ/Include; ../../../../uEZ/Source/Library/GUI/SEGGER/emWin; ../../../../uEZ/Source/Library/lwIP/src/include; ../../../../uEZ/Source/Library/lwIP/src; ../../../../uEZ/Source/Library/lwIP/Include; ../../../../uEZ/Source/Library/lwIP/src/include/ipv4
  group (top)
    ./: Config_Build.h uEZGUI_StartHere.icf
    ../../../../uEZ/Build/Generic/NXP/LPC4088/FreeRTOS/IAR/Debug-Trace/Exe/: uEZ_NXP_LPC4088_FreeRTOS_IAR_Debug-Trace.a
    ../../../../uEZ/Build/Generic/NXP/LPC4088/FreeRTOS/IAR/Debug/Exe/: uEZ_NXP_LPC4088_FreeRTOS_IAR_Debug.a
    ../../../../uEZ/Build/Generic/NXP/LPC4088/FreeRTOS/IAR/Release/Exe/: uEZ_NXP_LPC4088_FreeRTOS_IAR_Release.a
  group Include
    ../../../../uEZ/Include/: Config.h fcntl.h signal.h uEZ.h uEZADC.h uEZCharDisplay.h uEZDevice.h uEZDeviceTable.h uEZErrors.h uEZFile.h uEZI2C.h uEZKeypad.h uEZLCD.h uEZLEDBank.h uEZMemory.h uEZProcessor.h uEZRTOS.h uEZSPI.h uEZStream.h uEZTemperature.h uEZTickCounter.h uEZTimeDate.h uEZToneGenerator.h uEZTS.h uEZTypes.h unistd.h
  group Include/Device
    ../../../../uEZ/Include/Device/: Accelerometer.h ADCBank.h Backlight.h ButtonBank.h CharDisplay.h EEPROM.h ExternalInterrupt.h FileSystem.h Flash.h I2CBus.h Keypad.h LCD.h LEDBank.h MassStorage.h PWM.h RTC.h SPIBus.h Stream.h Temperature.h ToneGenerator.h Touchscreen.h USBDevice.h USBHost.h
  group Include/Device/LCD
    ../../../../uEZ/Include/Device/LCD/: Config_LCD.h
  group Include/HAL
    ../../../../uEZ/Include/HAL/: ADCBank.h EMAC.h GPIO.h HAL.h I2CBus.h Interrupt.h LCDController.h PWM.h RTC.h Serial.h SPI.h Timer.h USBDeviceController.h USBHost.h Watchdog.h
  group Include/netinet
    ../../../../uEZ/Include/netinet/: in.h
  group Include/sys
    ../../../../uEZ/Include/sys/: mman.h socket.h stat.h time.h types.h
  group Include/Types
    ../../../../uEZ/Include/Types/: Accelerometer.h ADC.h EEPROM.h EMAC.h File.h Flash.h I2C.h InputEvent.h LCD.h Serial.h SPI.h TimeDate.h USBDevice.h USBHost.h
  group Source/App
    ../../../Source/App/: Calibration.c Calibration.h Config_App.h main.c MyTask.c MyTask.h NVSettings.c NVSettings.h
  group Source/App/emWin
    ../../../Source/App/emWin/: Create_Window_Functions.h HomeScreen.c LookAndFeel.c LookAndFeel.h SecondScreen.c WindowManager.c WindowManager.h
  group Source/App/emWin/Fonts
    ../../../Source/App/emWin/Fonts/: Fonts.h
  group Source/App/emWin/Graphics
    ../../../Source/App/emWin/Graphics/: Graphics.h
  group Source/Library/GUI/SEGGER/emWin
    ../../../../uEZ/Source/Library/GUI/SEGGER/emWin/: BUTTON.h BUTTON_Private.h CHECKBOX.h CHECKBOX_Private.h DIALOG.h DIALOG_Intern.h DROPDOWN.h DROPDOWN_Private.h EDIT.h EDIT_Private.h FRAMEWIN.h FRAMEWIN_Private.h Global.h GRAPH.h GRAPH_Private.h GUI.h GUI_ARRAY.h GUI_ARRAY_Private.h GUI_BMP_Private.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_GIF_Private.h GUI_HOOK.h GUI_JPEG_Private.h GUI_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_Type.h GUI_Version.h GUI_VNC.h GUIDRV_07X1.h GUIDRV_13700.h GUIDRV_13748.h GUIDRV_1611.h GUIDRV_6331.h GUIDRV_7529.h GUIDRV_BitPlains.h GUIDRV_CompactColor_16.h GUIDRV_Fujitsu_16.h GUIDRV_Generic.h GUIDRV_GW7630_1.h GUIDRV_IST3088.h GUIDRV_IST3088_Private.h GUIDRV_L5F30919.h GUIDRV_Lin.h GUIDRV_Lin_Private.h GUIDRV_NoOpt_1_8.h GUIDRV_Page1bpp.h GUIDRV_S1D13748.h GUIDRV_S1D13748_Private.h GUIDRV_S1D13U11.h GUIDRV_S1D15G00.h GUIDRV_SLin.h GUIDRV_SLin_Private.h GUIDRV_SSD1926.h GUIDRV_SSD1926_Private.h GUIDRV_Template.h GUIDRV_TemplateI.h GUIDRV_TemplateI_Private.h GUIDRV_UC1698G4.h HEADER.h HEADER_Private.h ICONVIEW.h ICONVIEW_Private.h LCD.h LCD_ConfDefaults.h LCD_Private.h LCD_Protected.h LCD_SIM.h LISTBOX.h LISTBOX_Private.h LISTVIEW.h LISTVIEW_Private.h LISTWHEEL.h LISTWHEEL_Private.h MENU.h MENU_Private.h MESSAGEBOX.h MULTIEDIT.h MULTIPAGE.h MULTIPAGE_Private.h PROGBAR.h PROGBAR_Private.h RADIO.h RADIO_Private.h SCROLLBAR.h SCROLLBAR_Private.h SLIDER.h SLIDER_Private.h TEXT.h TEXT_Private.h TREEVIEW.h TREEVIEW_Private.h WIDGET.h WINDOW_Private.h WM.h WM_GUI.h WM_Intern.h WM_Intern_ConfDep.h
  group Source/Library/GUI/SEGGER/emWin/Library/NXP
    ../../../../uEZ/Source/Library/GUI/SEGGER/emWin/Libraries/NXP/IAR/: emWin_530_IAR_M4F.a
  group Source/Platform/FDI/uEZGUI_4088_43WQN
    ../../../../uEZ/Source/Platform/FDI/uEZGUI_4088_43WQN/: uEZGUI_4088_43WQN.c uEZPlatform.h
