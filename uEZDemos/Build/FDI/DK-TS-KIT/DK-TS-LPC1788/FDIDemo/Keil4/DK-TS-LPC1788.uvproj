# Keil uVision project DK-TS-LPC1788.uvproj, settings and files
target Debug (ARM-ADS)
  device: LPC1778 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: DK-TS-LPC1788 +hex
  c flags: Optim=1 wLevel=1
  c define: COMPILER_TYPE=Keil4, GCC_ARMCM3, DEBUG
  c include: .;../../../../../../.;../../../../../../Source/App/DKTSKit;../../../../../../Source/App/uEZDemoCommon;../../../../../../Source/App/SEGGER/emWin/GUIDEMO;../../../../../../../uEZ;../../../../../../../uEZ/Include;../../../../../../../uEZ/Source/Platform/FDI/CARRIER_1788;../../../../../../../uEZ/Source/Processor/NXP/LPC1788;../../../../../../../uEZ/Source/RTOS/FreeRTOS/include;../../../../../../../uEZ/Source/RTOS/FreeRTOS/portable/RVDS/ARM_CM3;../../../../../../../uEZ/Source/Library/lwIP/src/include;../../../../../../../uEZ/Source/Library/lwIP/src;../../../../../../../uEZ/Source/Library/lwIP/Include;../../../../../../../uEZ/Source/Library/lwIP/src/include/ipv4;../../../../../../../uEZ/Source/Platform/emWin/;../../../../../../../uEZ/Source/Platform/emWin/Config;../../../../../../../uEZ/Source/Platform/emWin/Inc;../../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin;../../../../../../../uEZ/Source/Processor/NXP/LPC1788/Keil4/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\DK-TS-LPC1788.sct
  link misc: --verbose
  group Build
    ./: Config_Build.h
  group Include
    ../../../../../Include/: Config.h
  group Source/App/DKTSKit
    ../../../../../../Source/App/DKTSKit/: AppTasks.c Audio.c CANTest.c FunctionalTest.c FunctionalTestLoop.c main.c MainMenu.c
  group Source/App/uEZDemoCommon
    ../../../../../../Source/App/uEZDemoCommon/: AccelDemoMode.c AppMenu.c BrightnessControlMode.c Calibration.c ConsoleMode.c DrawMode.c MultiSlideshowMode.c SingleSlideshowMode.c TempMode.c TimeDateMode.c UDCImages.c YourAppMode.c NVSettings.c
  group Library
    ../../../../../../../uEZ/Build/Generic/NXP/LPC1788/FreeRTOS/Keil4.x/Debug/: uEZ_NXP_LPC1788_FreeRTOS_Keil_Debug.lib
  group Source/Platform/FDI/CARRIER_1788
    ../../../../../../../uEZ/Source/Platform/FDI/CARRIER_1788/: CARRIER_LPC1788.c
