# IAR project DK-TS-LPC2478.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2478 NXP LPC2478
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: LPC2000_IAR; COMPILER_TYPE=IAR
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.IExtraOptions: --no_unaligned_access; --enum_is_int
  ICCARM.CCIncludePath2: .; ../../../../../../.; ../../../../../../Source/App/DKTSKit; ../../../../../../Source/App/uEZDemoCommon; ../../../../../../Source/App/SEGGER/emWin/GUIDEMO; ../../../../../../../uEZ; ../../../../../../../uEZ/Include; ../../../../../../../uEZ/Source/Platform/FDI/CARRIER_2478; ../../../../../../../uEZ/Source/Processor/NXP/LPC2478; ../../../../../../../uEZ/Source/Processor/NXP/LPC2478/IAR; ../../../../../../../uEZ/Source/RTOS/FreeRTOS/include; ../../../../../../../uEZ/Source/RTOS/FreeRTOS/portable/IAR/LPC2000; ../../../../../../../uEZ/Source/Library/lwIP/src/include; ../../../../../../../uEZ/Source/Library/lwIP/src; ../../../../../../../uEZ/Source/Library/lwIP/Include; ../../../../../../../uEZ/Source/Library/lwIP/src/include/ipv4; ../../../../../../../uEZ/Source/Platform/emWin/; ../../../../../../../uEZ/Source/Platform/emWin/Config; ../../../../../../../uEZ/Source/Platform/emWin/Inc; ../../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: .; ../../../../../.; ../../../../../Source/App/Demos/DKTSKit; ../../../../../Source/Platform/FDI/CARRIER_2478; ../../../../../Source/Processor/NXP/LPC2478; ../../../../../Include; ../../../../../Source/RTOS/FreeRTOS/include; ../../../../../Source/RTOS/FreeRTOS/portable/IAR/LPC2000; ../../../../../Source/Library/lwIP/src/include; ../../../../../Source/Library/lwIP/src; ../../../../../Source/Library/lwIP/Include; ../../../../../Source/Library/lwIP/src/include/ipv4; ../../../../../Source/Library/lwIP/src/arch; ../../../../../Source/App/Demos/FDI/SEGGER/emWin/GUIDEMO; ../../../../../Source/Platform/emWin/; ../../../../../Source/Platform/emWin/Config; ../../../../../Source/Platform/emWin/Inc; ../../../../../Source/Library/GUI/SEGGER/emWin
  OBJCOPY.OOCOutputFile: DK-TS-LPC2478.hex
  ILINK.IlinkOutputFile: DK-TS-LPC2478.out
  ILINK.IlinkIcfFile: ../../../../../../../uEZ/Source/Platform\FDI\CARRIER_2478\IAR\ROM_config SDRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; LPC2000_IAR; COMPILER_TYPE=IAR
  ICCARM.CCOptLevel: 3
  group (top)
    ./: Config_Build.h
    ../../../../../../../uEZ/Build/Generic/NXP/LPC2478/FreeRTOS/IAR6.x/Debug/Exe/: uEZ_NXP_LPC2478_FreeRTOS_IAR6_Debug.a
    ../../../../../../../uEZ/Build/Generic/NXP/LPC2478/FreeRTOS/IAR6.x/Release/Exe/: uEZ_NXP_LPC2478_FreeRTOS_IAR6_Release.a
  group Include
    ../../../../../Include/: Config.h fcntl.h FreeRTOSConfig.h netdb.h signal.h uEZ.h uEZADC.h uEZCharDisplay.h uEZDevice.h uEZDeviceTable.h uEZErrors.h uEZFile.h uEZI2C.h uEZKeypad.h uEZLCD.h uEZLEDBank.h uEZMemory.h uEZProcessor.h uEZRTOS.h uEZSPI.h uEZStream.h uEZTemperature.h uEZTickCounter.h uEZTimeDate.h uEZToneGenerator.h uEZTS.h uEZTypes.h unistd.h
  group Include/Device
    ../../../../../Include/Device/: Accelerometer.h ADCBank.h Backlight.h ButtonBank.h CharDisplay.h ExternalInterrupt.h FileSystem.h Flash.h I2CBus.h Keypad.h LCD.h LEDBank.h MassStorage.h PWM.h RTC.h SPIBus.h Stream.h Temperature.h ToneGenerator.h Touchscreen.h USBDevice.h USBHost.h
    ../../../../../nclude/Device/: EEPROM.h
  group Include/Device/LCD
    ../../../../../Include/Device/LCD/: Config_LCD.h
  group Include/HAL
    ../../../../../Include/HAL/: ADCBank.h EMAC.h GPIO.h HAL.h I2CBus.h Interrupt.h LCDController.h PWM.h RTC.h Serial.h SPI.h Timer.h USBDeviceController.h USBHost.h
  group Include/netinet
    ../../../../../Include/netinet/: in.h
  group Include/sys
    ../../../../../Include/sys/: mman.h socket.h stat.h time.h types.h
  group Include/Types
    ../../../../../Include/Types/: Accelerometer.h ADC.h EEPROM.h EMAC.h File.h Flash.h I2C.h InputEvent.h LCD.h Serial.h SPI.h TimeDate.h USBDevice.h USBHost.h
  group Source/App/DKTSKit
    ../../../../../../Source/App/DKTSKit/: AppDemo.h AppTasks.c AppTasks.h CANTest.c Config_App.h FunctionalTest.c FunctionalTestLoop.c main.c MainMenu.c ProgramTag.h
  group Source/App/uEZDemoCommon
    ../../../../../../Source/App/uEZDemoCommon/: AccelDemoMode.c AppMenu.c AppMenu.h Audio.c Audio.h BrightnessControlMode.c Calibration.c Calibration.h ConsoleMode.c DrawMode.c MultiSlideshowMode.c NVSettings.c NVSettings.h SingleSlideshowMode.c SingleSlideshowMode.h Slideshow.h TempMode.c TimeDateMode.c UDCImages.c UDCImages.h uEZDemoCommon.h YourAppMode.c
  group Source/Library/GUI/SEGGER/emWin/Library/Trial
    ../../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin/Libraries/Trial/IAR/ARM_IAR_V6/: GUIv5_4t_tl_i_trial.a
  group Source/Platform/FDI/CARRIER
    ../../../../../../../uEZ/Source/Platform/FDI/CARRIER_2478/: CARRIER_LPC2478.c lwipopts.h UEZPlatform.h
