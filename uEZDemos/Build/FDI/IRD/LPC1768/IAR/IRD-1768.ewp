# IAR project IRD-1768.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: LWIP_2_0_x
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: .; ../../../../../Source/App/IRDDemo; ../../../../../Source/App/uEZGUI; ../../../../../Source/App/uEZDemoCommon; ../../../../../Source/App/SEGGER/emWin/GUIDEMO; ../../../../../../uEZ; ../../../../../../uEZ/Include; ../../../../../../uEZ/Source/Platform/NXP/IRD; ../../../../../../uEZ/Source/Processor/NXP/LPC1768; ../../../../../../uEZ/Source/Processor/NXP/LPC1768/IAR/include; ../../../../../../uEZ/Source/RTOS/FreeRTOS/include; ../../../../../../uEZ/Source/RTOS/FreeRTOS/portable/IAR/ARM_CM3; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/src/include; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/src; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/Include; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/src/include/ipv4; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/system; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/system/arch; ../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin; ../../../../../../uEZ/Source/Platform/emWin/Inc; ../../../../../../uEZ/Source/Platform/emWin/Config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: UEZGUIDemo.hex
  ILINK.IlinkOutputFile: IRD-1768.out
  ILINK.IlinkIcfFile: IRD-1768.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: LWIP_2_0_x; NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: IRD-1768.hex
  group (top)
    ./: Config_Build.h IRD-1768.icf
    ../../../../../../uEZ/Build/Generic/NXP/LPC1768/FreeRTOS/IAR/Debug/Exe/: uEZ_NXP_LPC1768_FreeRTOS_IAR_Debug.a
    ../../../../../../uEZ/Build/Generic/NXP/LPC1768/FreeRTOS/IAR/Release/Exe/: uEZ_NXP_LPC1768_FreeRTOS_IAR_Release.a
  group flash_loader
    flash_loader/: LPC177x_8x.mac uEZGUI_1768_70WVE.board uEZGUI_1768_70WVE.flash
  group flash_loader NOR
    flash_loader NOR/: LPC177x_8x.mac uEZGUI_1768_70WVE_NOR.board uEZGUI_1768_70WVE_NOR.flash uEZGUI_1768_NOR.icf
  group Include
    ../../../../../../uEZ/Include/: Config.h fcntl.h signal.h uEZ.h uEZADC.h uEZCharDisplay.h uEZDevice.h uEZDeviceTable.h uEZErrors.h uEZFile.h uEZI2C.h uEZKeypad.h uEZLCD.h uEZLEDBank.h uEZMemory.h uEZProcessor.h uEZRTOS.h uEZSPI.h uEZStream.h uEZTemperature.h uEZTickCounter.h uEZTimeDate.h uEZToneGenerator.h uEZTS.h uEZTypes.h unistd.h
  group Include/Device
    ../../../../../../uEZ/Include/Device/: Accelerometer.h ADCBank.h Backlight.h ButtonBank.h CharDisplay.h EEPROM.h ExternalInterrupt.h FileSystem.h Flash.h I2CBus.h Keypad.h LCD.h LEDBank.h MassStorage.h PWM.h RTC.h SPIBus.h Stream.h Temperature.h ToneGenerator.h Touchscreen.h USBDevice.h USBHost.h
  group Include/Device/LCD
    ../../../../../../uEZ/Include/Device/LCD/: Config_LCD.h
  group Include/HAL
    ../../../../../../uEZ/Include/HAL/: ADCBank.h EMAC.h GPIO.h HAL.h I2CBus.h Interrupt.h LCDController.h PWM.h RTC.h Serial.h SPI.h Timer.h USBDeviceController.h USBHost.h Watchdog.h
  group Include/netinet
    ../../../../../../uEZ/Include/netinet/: in.h
  group Include/sys
    ../../../../../../uEZ/Include/sys/: mman.h socket.h stat.h time.h types.h
  group Include/Types
    ../../../../../../uEZ/Include/Types/: Accelerometer.h ADC.h EEPROM.h EMAC.h File.h Flash.h I2C.h InputEvent.h LCD.h Serial.h SPI.h TimeDate.h USBDevice.h USBHost.h
  group Source/App/IRDDemo
    ../../../../../Source/App/IRDDemo/: AppDemo.h AppTasks.c AppTasks.h Config_App.h main.c NVSettings.c NVSettings.h
  group Source/Library/Web/BasicWeb
    ../../../../../../uEZ/Source/Library/Web/BasicWeb/: BasicWEB.c BasicWEB.h
  group Source/Platform/NXP/IRD
    ../../../../../../uEZ/Source/Platform/NXP/IRD/: lwipopts.h NXP_1768_IRD1.0.c uEZPlatform.h
  group Source/RTOS/FreeRTOS/MemMang
    ../../../../../../uEZ/Source/RTOS/FreeRTOS/portable/MemMang/: heap_2.c
