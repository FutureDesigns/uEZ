# IAR project uEZGUI-35Cx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54608J512 NXP LPC54608J512
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: IAR_ARM_CM4F; CORE_M4
  ICCARM.IExtraOptions: --no_unaligned_access; --enum_is_int
  ICCARM.CCIncludePath2: .; ../../../../../Source/App/uEZGUI; ../../../../../Source/App/uEZDemoCommon; ../../../../../Source/App/SEGGER/emWin/GUIDEMO; ../../../../../../uEZ; ../../../../../../uEZ/Include; ../../../../../../uEZ/Source/Platform/FDI/uEZGUI_35Cx; ../../../../../../uEZ/Source/Processor/NXP/LPC546xx; ../../../../../../uEZ/Source/Processor/NXP/LPC546xx/IAR/include; ../../../../../../uEZ/Source/Processor/NXP/LPC546xx/IAR/include/CMSIS; ../../../../../../uEZ/Source/RTOS/FreeRTOS/include; ../../../../../../uEZ/Source/RTOS/FreeRTOS/; ../../../../../../uEZ/Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../../../uEZ/Source/Library/lwIP/src/include; ../../../../../../uEZ/Source/Library/lwIP/src; ../../../../../../uEZ/Source/Library/lwIP/Include; ../../../../../../uEZ/Source/Library/lwIP/src/include/ipv4; ../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin; ../../../../../../uEZ/Source/Platform/emWin/Inc; ../../../../../../uEZ/Source/Platform/emWin/Config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../../../../../../uEZ; ../../../../../../uEZ/Build/uEZGUI/uEZGUI-35Cx/IAR; ../../../../../../uEZ/Source/App/Demos/uEZGUI; ../../../../../../uEZ/Source/App/Demos/FDI/SEGGER/emWin/GUIDEMO; ../../../../../../uEZ/Source/Platform/FDI/uEZGUI_35Cx; ../../../../../../uEZ/Source/Platform/emWin/; ../../../../../../uEZ/Source/Platform/emWin/Config; ../../../../../../uEZ/Source/Platform/emWin/Inc; ../../../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx; ../../../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx/IAR/include; ../../../../../../uEZ/Include; ../../../../../../uEZ/Source/RTOS/FreeRTOS/include; ../../../../../../uEZ/Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin; ../../../../../../uEZ/Source/Library/lwIP/src/include; ../../../../../../uEZ/Source/Library/lwIP/src; ../../../../../../uEZ/Source/Library/lwIP/Include; ../../../../../../uEZ/Source/Library/lwIP/src/include/ipv4
  OBJCOPY.OOCOutputFile: uEZGUI-35Cx.hex
  ILINK.IlinkOutputFile: uEZGUI-35Cx.out
  ILINK.IlinkIcfFile: uEZGUI-35Cx.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../uEZ\Source\Processor\NXP\LPC546xx\IAR\iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; IAR_ARM_CM4F; CORE_M4
  ICCARM.CCIncludePath2: .; ../../../../../Source/App/uEZGUI; ../../../../../Source/App/uEZDemoCommon; ../../../../../Source/App/SEGGER/emWin/GUIDEMO; ../../../../../../uEZ; ../../../../../../uEZ/Include; ../../../../../../uEZ/Source/Platform/FDI/uEZGUI_35Cx; ../../../../../../uEZ/Source/Processor/NXP/LPC546xx; ../../../../../../uEZ/Source/Processor/NXP/LPC546xx/IAR/include; ../../../../../../uEZ/Source/Processor/NXP/LPC546xx/IAR/include/CMSIS; ../../../../../../uEZ/Source/RTOS/FreeRTOS/include; ../../../../../../uEZ/Source/RTOS/FreeRTOS/; ../../../../../../uEZ/Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../../../uEZ/Source/Library/lwIP/src/include; ../../../../../../uEZ/Source/Library/lwIP/src; ../../../../../../uEZ/Source/Library/lwIP/Include; ../../../../../../uEZ/Source/Library/lwIP/src/include/ipv4; ../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin; ../../../../../../uEZ/Source/Platform/emWin/Inc; ../../../../../../uEZ/Source/Platform/emWin/Config; ../../../../../../uEZ/Source/Library/LPCOpen/chip_18xx_43xx
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: LPC546xx_m4_SDRAM.icf
configuration Debug-Trace (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC546xx_M4 NXP LPC546xx_M4
  ICCARM.CCDefines: IAR_ARM_CM4F; CORE_M4; FREERTOS_PLUS_TRACE
  ICCARM.CCIncludePath2: .; ../../../../../Source/App/uEZGUI; ../../../../../Source/App/uEZDemoCommon; ../../../../../Source/App/SEGGER/emWin/GUIDEMO; ../../../../../../uEZ; ../../../../../../uEZ/Include; ../../../../../../uEZ/Source/Platform/FDI/uEZGUI_35Cx; ../../../../../../uEZ/Source/Processor/NXP/LPC546xx; ../../../../../../uEZ/Source/Processor/NXP/LPC546xx/IAR/include; ../../../../../../uEZ/Source/Processor/NXP/LPC546xx/IAR/include/CMSIS; ../../../../../../uEZ/Source/RTOS/FreeRTOS/include; ../../../../../../uEZ/Source/RTOS/FreeRTOS/; ../../../../../../uEZ/Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../../../uEZ/Source/RTOS/FreeRTOS-Plus/FreeRTOS-Plus-Trace/include; ../../../../../../uEZ/Source/Library/lwIP/src/include; ../../../../../../uEZ/Source/Library/lwIP/src; ../../../../../../uEZ/Source/Library/lwIP/Include; ../../../../../../uEZ/Source/Library/lwIP/src/include/ipv4; ../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin; ../../../../../../uEZ/Source/Platform/emWin/Inc; ../../../../../../uEZ/Source/Platform/emWin/Config; ../../../../../../uEZ/Source/Library/LPCOpen/chip_18xx_43xx
  ILINK.IlinkIcfFile: LPC546xx_m4_SDRAM.icf
  group (top)
    ./: Config_Build.h uEZGUI-35Cx.icf
    ../../../../../../uEZ/Build/Generic/NXP/LPC546xx/FreeRTOS/IAR/Debug-Trace/Exe/: uEZ_NXP_LPC546xx_FreeRTOS_IAR_Debug-Trace.a
    ../../../../../../uEZ/Build/Generic/NXP/LPC546xx/FreeRTOS/IAR/Debug/Exe/: uEZ_NXP_LPC546xx_FreeRTOS_IAR_Debug.a
    ../../../../../../uEZ/Build/Generic/NXP/LPC546xx/FreeRTOS/IAR/Release/Exe/: uEZ_NXP_LPC546xx_FreeRTOS_IAR_Release.a
  group Include
    ../../../../../../uEZ/Include/: Config.h fcntl.h FreeRTOSConfig.h signal.h uEZ.h uEZADC.h uEZCharDisplay.h uEZDevice.h uEZDeviceTable.h uEZErrors.h uEZFile.h uEZI2C.h uEZKeypad.h uEZLCD.h uEZLEDBank.h uEZMemory.h uEZProcessor.h uEZRTOS.h uEZSPI.h uEZStream.h uEZTemperature.h uEZTickCounter.h uEZTimeDate.h uEZToneGenerator.h uEZTS.h uEZTypes.h unistd.h
  group Include/Device
    ../../../../../../uEZ/Include/Device/: Accelerometer.h ADCBank.h Backlight.h ButtonBank.h CharDisplay.h EEPROM.h ExternalInterrupt.h FileSystem.h Flash.h I2CBus.h Keypad.h LCD.h LEDBank.h MassStorage.h PWM.h RTC.h SPIBus.h Stream.h Temperature.h ToneGenerator.h Touchscreen.h USBDevice.h USBHost.h
  group Include/Device/LCD
    ../../../../../../uEZ/Include/Device/LCD/: Config_LCD.h
  group Include/HAL
    ../../../../../../uEZ/Include/HAL/: ADCBank.h EMAC.h GPIO.h HAL.h I2CBus.h Interrupt.h LCDController.h PWM.h RTC.h Serial.h SPI.h Timer.h USBDeviceController.h USBHost.h Watchdog.h
  group Include/netinet
    ../../../../../../uEZ/Include/netinet/: in.h
  group Include/sys
    ../../../../../../uEZ/Include/sys/: mman.h socket.h stat.h time.h types.h
  group Include/Types
    ../../../../../../uEZ/Include/Types/: Accelerometer.h ADC.h EEPROM.h EMAC.h File.h Flash.h I2C.h InputEvent.h LCD.h Serial.h SPI.h TimeDate.h USBDevice.h USBHost.h
  group Source/App/SEGGER/emWin
    ../../../../../Source/App/SEGGER/emWin/: emWin.c
  group Source/App/SEGGER/emWin/GUIDEMO
    ../../../../../Source/App/SEGGER/emWin/GUIDEMO/: GUIDEMO.c GUIDEMO.h GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group Source/App/uEZDemoCommon
    ../../../../../Source/App/uEZDemoCommon/: AccelDemoMode.c AppHTTPServer.c AppHTTPServer.h AppMenu.c AppMenu.h Audio.c Audio.h AudioPlayer.h BrightnessControlMode.c Calibration.c Calibration.h CANTest.c ConsoleMode.c DrawMode.c MultiSlideshowMode.c NetworkStartup.c NetworkStartup.h NVSettings.c NVSettings.h SingleSlideshowMode.c SingleSlideshowMode.h Slideshow.h TempMode.c TimeDateMode.c UDCImages.c UDCImages.h uEZDemoCommon.h VideoPlayer.c VideoPlayer.h VideoPlayerSelection.c YourAppMode.c
  group Source/App/uEZGUI
    ../../../../../Source/App/uEZGUI/: AppDemo.h AppTasks.c AppTasks.h Config_App.h FuncTestFramework.h FunctionalTest.c FunctionalTest.h FunctionalTest_EXP_DK.c FunctionalTest_EXP_DK.h FunctionalTestLoop.c main.c MainMenu.c TestCmds.c TestCmds.h TestMode.c
  group Source/ExpansionBoard/FDI/uEZGUI_EXP_DK
    ../../../../../../uEZ/Source/ExpansionBoard/FDI/uEZGUI_EXP_DK/: uEZGUI_EXP_DK.c uEZGUI_EXP_DK.h
  group Source/Library/GUI/SEGGER/emWin
    ../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin/: BUTTON.h BUTTON_Private.h CHECKBOX.h CHECKBOX_Private.h DIALOG.h DIALOG_Intern.h DROPDOWN.h DROPDOWN_Private.h EDIT.h EDIT_Private.h FRAMEWIN.h FRAMEWIN_Private.h Global.h GRAPH.h GRAPH_Private.h GUI.h GUI_ARRAY.h GUI_ARRAY_Private.h GUI_BMP_Private.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_GIF_Private.h GUI_HOOK.h GUI_JPEG_Private.h GUI_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_Type.h GUI_Version.h GUI_VNC.h GUIDRV_07X1.h GUIDRV_13700.h GUIDRV_13748.h GUIDRV_1611.h GUIDRV_6331.h GUIDRV_7529.h GUIDRV_BitPlains.h GUIDRV_CompactColor_16.h GUIDRV_Fujitsu_16.h GUIDRV_Generic.h GUIDRV_GW7630_1.h GUIDRV_IST3088.h GUIDRV_IST3088_Private.h GUIDRV_L5F30919.h GUIDRV_Lin.h GUIDRV_Lin_Private.h GUIDRV_NoOpt_1_8.h GUIDRV_Page1bpp.h GUIDRV_S1D13748.h GUIDRV_S1D13748_Private.h GUIDRV_S1D13U11.h GUIDRV_S1D15G00.h GUIDRV_SLin.h GUIDRV_SLin_Private.h GUIDRV_SSD1926.h GUIDRV_SSD1926_Private.h GUIDRV_Template.h GUIDRV_TemplateI.h GUIDRV_TemplateI_Private.h GUIDRV_UC1698G4.h HEADER.h HEADER_Private.h ICONVIEW.h ICONVIEW_Private.h LCD.h LCD_ConfDefaults.h LCD_Private.h LCD_Protected.h LCD_SIM.h LISTBOX.h LISTBOX_Private.h LISTVIEW.h LISTVIEW_Private.h LISTWHEEL.h LISTWHEEL_Private.h MENU.h MENU_Private.h MESSAGEBOX.h MULTIEDIT.h MULTIPAGE.h MULTIPAGE_Private.h PROGBAR.h PROGBAR_Private.h RADIO.h RADIO_Private.h SCROLLBAR.h SCROLLBAR_Private.h SLIDER.h SLIDER_Private.h TEXT.h TEXT_Private.h TREEVIEW.h TREEVIEW_Private.h WIDGET.h WINDOW_Private.h WM.h WM_GUI.h WM_Intern.h WM_Intern_ConfDep.h
  group Source/Library/GUI/SEGGER/emWin/Library/NXP
    ../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin/Libraries/NXP/IAR/: emWin_530_IAR_M4F.a
  group Source/Platform/FDI/uEZGUI_35Cx
    ../../../../../../uEZ/Source/Platform/FDI/uEZGUI_35Cx/: uEZGUI_35Cx.c uEZPlatform.h
  group Source/Testing
    ../../../../../../uEZ/Source/Devices/EEPROM/NXP/LPC546xx/: EEPROM_NXP_LPC546xx.c EEPROM_NXP_LPC546xx.h
    ../../../../../../uEZ/Source/Devices/Touchscreen/Himax/HX8526-A/: HX8526-A_TouchScreen.c
    ../../../../../../uEZ/Source/Processor/NXP/LPC546xx/: LPC546xx_ADCBank.c LPC546xx_CRC.c LPC546xx_EMAC.c LPC546xx_ExternalBus.c LPC546xx_GPIO.c LPC546xx_HALInit.c LPC546xx_I2C.c LPC546xx_Interrupt.c LPC546xx_LCDController.c LPC546xx_PLL.c LPC546xx_RTC.c LPC546xx_SD_MMC.c LPC546xx_SDRAM.c LPC546xx_SPI.c LPC546xx_UtilityFuncs.c
    ../../../../../../uEZ/Source/Devices/LCD/Tianma/TM035KBH02-09/: Tianma_TM035KBH02_09.c
