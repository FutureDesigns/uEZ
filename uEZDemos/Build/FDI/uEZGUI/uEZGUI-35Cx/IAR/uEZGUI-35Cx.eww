<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\uEZGUI-35Cx.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>uEZGUI-35Cx</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>uEZGUI-35Cx</project>
        <configuration>Debug-Trace</configuration>
      </member>
      <member>
        <project>uEZGUI-35Cx</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


