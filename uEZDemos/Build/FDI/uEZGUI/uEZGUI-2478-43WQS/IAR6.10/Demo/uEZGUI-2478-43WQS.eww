<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\uEZGUI-2478-43WQS.ewp</path>
  </project>
  <batchBuild/>
</workspace>


