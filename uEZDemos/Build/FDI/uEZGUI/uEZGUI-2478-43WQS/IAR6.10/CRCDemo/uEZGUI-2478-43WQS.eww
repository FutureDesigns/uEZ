<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\..\..\..\..\uEZ\Build\Generic\NXP\LPC2478\FreeRTOS\IAR6.x\uEZ_NXP_LPC2478_FreeRTOS_IAR6.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\uEZGUI-2478-43WQS.ewp</path>
  </project>
  <batchBuild/>
</workspace>


