# IAR project uEZGUI-2478-43WQS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2478 NXP LPC2478
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: LPC2000_IAR; COMPILER_TYPE=IAR
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.IExtraOptions: --no_unaligned_access; --enum_is_int
  ICCARM.CCIncludePath2: ../../../../../../../uEZ/; ../../../../../../../uEZ/Build/uEZGUI/uEZGUI-2478-43WQS/IAR6.10/Demo; ../../../../../../../uEZ/Source/App/Demos/uEZGUI; ../../../../../../../uEZ/Source/App/Demos/FDI/SEGGER/emWin/GUIDEMO; ../../../../../../../uEZ/Source/Platform/FDI/uEZGUI-2478-43WQS; ../../../../../../../uEZ/Source/Platform/emWin; ../../../../../../../uEZ/Source/Platform/emWin/Config; ../../../../../../../uEZ/Source/Platform/emWin/Inc; ../../../../../../../uEZ/Source/Processor/NXP/LPC2478; ../../../../../../../uEZ/Source/Processor/NXP/LPC2478/IAR/include; ../../../../../../../uEZ/Include; ../../../../../../../uEZ/Source/RTOS/FreeRTOS/include; ../../../../../../../uEZ/Source/RTOS/FreeRTOS/portable/IAR/LPC2000; ../../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin; ../../../../../../../uEZ/Source/Library/lwIP/src/include; ../../../../../../../uEZ/Source/Library/lwIP/src; ../../../../../../../uEZ/Source/Library/lwIP/Include; ../../../../../../../uEZ/Source/Library/lwIP/src/include/ipv4
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: uEZGUI-2478-43WQS.hex
  ILINK.IlinkOutputFile: UEZGUIDemo.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\..\uEZ\..\uEZ\Source\Platform\FDI\uEZGUI-2478-43WQS\IAR\ROM_config SDRAM NOR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; LPC2000_IAR; COMPILER_TYPE=IAR
  ICCARM.CCOptLevel: 3
  group (top)
    ./: Config_Build.h
    ../../../../../../../uEZ/Build/Generic/NXP/LPC2478/FreeRTOS/IAR6.x/Debug/Exe/: uEZ_NXP_LPC2478_FreeRTOS_IAR6_Debug.a
    ../../../../../../../uEZ/Build/Generic/NXP/LPC2478/FreeRTOS/IAR6.x/Release/Exe/: uEZ_NXP_LPC2478_FreeRTOS_IAR6_Release.a
    Debug/List/: UEZGUIDemo.map
  group Include
    ../../../../../../../uEZ/Include/: Config.h fcntl.h FreeRTOSConfig.h netdb.h signal.h uEZ.h uEZADC.h uEZCharDisplay.h uEZCRC.h uEZDevice.h uEZDeviceTable.h uEZErrors.h uEZFile.h uEZI2C.h uEZKeypad.h uEZLCD.h uEZLEDBank.h uEZMemory.h uEZProcessor.h uEZRTOS.h uEZSPI.h uEZStream.h uEZTemperature.h uEZTickCounter.h uEZTimeDate.h uEZToneGenerator.h uEZTS.h uEZTypes.h unistd.h
  group Include/Device
    ../../../../../../../uEZ/Include/Device/: Accelerometer.h ADCBank.h Backlight.h ButtonBank.h CharDisplay.h CRC.h EEPROM.h ExternalInterrupt.h FileSystem.h Flash.h I2CBus.h Keypad.h LCD.h LEDBank.h MassStorage.h PWM.h RTC.h SPIBus.h Stream.h Temperature.h ToneGenerator.h Touchscreen.h USBDevice.h USBHost.h
  group Include/Device/LCD
    ../../../../../../../uEZ/Include/Device/LCD/: Config_LCD.h
  group Include/HAL
    ../../../../../../../uEZ/Include/HAL/: ADCBank.h CRC.h EMAC.h GPIO.h HAL.h I2CBus.h Interrupt.h LCDController.h PWM.h RTC.h Serial.h SPI.h Timer.h USBDeviceController.h USBHost.h
  group Include/netinet
    ../../../../../../../uEZ/Include/netinet/: in.h
  group Include/sys
    ../../../../../../../uEZ/Include/sys/: mman.h socket.h stat.h time.h types.h
  group Include/Types
    ../../../../../../../uEZ/Include/Types/: Accelerometer.h ADC.h CRC.h EEPROM.h EMAC.h File.h Flash.h I2C.h InputEvent.h LCD.h Serial.h SPI.h TimeDate.h USBDevice.h USBHost.h
  group Source/App/Demos/FDI/SEGGER
    ../../../../../../../uEZ/Source/App/Demos/FDI/SEGGER/emWin/: emWin.c
  group Source/App/Demos/FDI/SEGGER/GUIDEMO
    ../../../../../../../uEZ/Source/App/Demos/FDI/SEGGER/emWin/GUIDEMO/: GUIDEMO.c GUIDEMO.h GUIDEMO_Automotive.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group Source/App/Demos/FDI/uEZDemoCommon
    ../../../../../../../uEZ/Source/App/Demos/FDI/uEZDemoCommon/: AccelDemoMode.c AppMenu.c AppMenu.h BrightnessControlMode.c Calibration.c Calibration.h ConsoleMode.c DrawMode.c MultiSlideshowMode.c SingleSlideshowMode.c Slideshow.h TempMode.c TimeDateMode.c UDCImages.c UDCImages.h uEZDemoCommon.h YourAppMode.c
  group Source/App/Demos/uEZGUI-2478-43WQS
    ../../../../../../../uEZ/Source/App/Demos/uEZGUI/: AppDemo.h AppTasks.c AppTasks.h Audio.c Audio.h Config_App.h Drawing.h FuncTestFramework.h FunctionalTest.c FunctionalTest.h main.c MainMenu.c NVSettings.c NVSettings.h TestCmds.c TestCmds.h TestMode.c
  group Source/Library/GUI/SEGGER/emWin/Library/Trial
    ../../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin/Libraries/Trial/IAR/ARM_IAR_V6/: GUIv5_4t_al_i_trial.a
  group Source/Platform/FDI/uEZGUI_2478_43WQS
    ../../../../../../../uEZ/Source/Platform/FDI/uEZGUI_2478_43WQS/: lwipopts.h uEZGUI_2478_43WQS.c UEZPlatform.h
