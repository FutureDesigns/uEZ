<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\uEZGUI-2478-70WVE.ewp</path>
  </project>
  <batchBuild/>
</workspace>


