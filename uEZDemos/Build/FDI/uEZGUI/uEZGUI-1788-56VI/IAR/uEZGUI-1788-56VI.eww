<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\uEZGUI-1788-56VI.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>uEZGUI-1788-56VI</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>uEZGUI-1788-56VI</project>
        <configuration>Debug-Trace</configuration>
      </member>
      <member>
        <project>uEZGUI-1788-56VI</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


