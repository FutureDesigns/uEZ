# Keil uVision project uEZGUI-1788-56VI.uvprojx, settings and files
target Debug (ARM-ADS)
  device: LPC1788 NXP
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uEZGUI-1788-56VI +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: COMPILER_TYPE=Keil4, GCC_ARMCM3, DEBUG
  c include: .;..\..\..\..\..\..\Source\App\uEZGUI;..\..\..\..\..\..\Source\App\uEZDemoCommon;..\..\..\..\..\..\Source\App\SEGGER\emWin\GUIDEMO;..\..\..\..\..\..\..\uEZ;..\..\..\..\..\..\..\uEZ\Include;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP\Include;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP\src\include;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP\src;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP\src\include\ipv4;..\..\..\..\..\..\..\uEZ\Source\RTOS\FreeRTOS\include;..\..\..\..\..\..\..\uEZ\Source\Platform\FDI\UEZGUI_1788_56VI;..\..\..\..\..\..\..\uEZ\Source\Processor\NXP\LPC17xx_40xx;..\..\..\..\..\..\..\uEZ\Source\Processor\NXP\LPC17xx_40xx\Keil4\include;..\..\..\..\..\..\..\uEZ\Source\Library\GUI\SEGGER\emWin;..\..\..\..\..\..\..\uEZ\Source\Platform\emWin\Inc;..\..\..\..\..\..\..\uEZ\Source\Platform\emWin\Config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\uEZGUI-1788-56VI.sct
  link misc: --verbose
  group Build
    ./: Config_Build.h
  group Include
    ../../../../Include/: Config.h
  group uEZGUI
    ../../../../../../Source/App/uEZGUI/: AppDemo.h AppTasks.c AppTasks.h Config_App.h FuncTestFramework.h FunctionalTest.c FunctionalTest.h main.c MainMenu.c TestCmds.c TestCmds.h TestMode.c FunctionalTest_EXP_DK.c FunctionalTest_EXP_DK.h FunctionalTestLoop.c
  group uEZDemoCommon
    ../../../../../../Source/App/uEZDemoCommon/: AccelDemoMode.c AppMenu.c AppMenu.h Audio.c Audio.h AudioPlayer.h BrightnessControlMode.c Calibration.c Calibration.h ConsoleMode.c DrawMode.c MultiSlideshowMode.c NVSettings.c NVSettings.h SingleSlideshowMode.c SingleSlideshowMode.h Slideshow.h TempMode.c TimeDateMode.c UDCImages.c UDCImages.h uEZDemoCommon.h YourAppMode.c VideoPlayer.c VideoPlayerSelection.c AppHTTPServer.c AppHTTPServer.h NetworkStartup.c CANTest.c
  group SEGGER/emWin
    ../../../../../../Source/App/SEGGER/emWin/: emWin.c
  group SEGGER/emWin/GUIDemo
    ../../../../../../Source/App/SEGGER/emWin/GUIDEMO/: GUIDEMO.c GUIDEMO_Automotive.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c GUIDEMO_AntialiasedText.c GUIDEMO_BarGraph.c GUIDEMO_Conf.c
  group Library
    ../../../../../../../uEZ/Build/Generic/NXP/LPC1788/FreeRTOS/Keil/Debug/: uEZ_NXP_LPC1788_FreeRTOS_Keil_Debug.lib
    ../../../../../../../uEZ/Build/Generic/NXP/LPC1788/FreeRTOS/Keil/Debug-Trace/: uEZ_NXP_LPC1788_FreeRTOS_Keil_Debug-Trace.lib
    ../../../../../../../uEZ/Build/Generic/NXP/LPC1788/FreeRTOS/Keil/Release/: uEZ_NXP_LPC1788_FreeRTOS_Keil_Release.lib
  group Source/Library/GUI/SEGGER/emWin/Library/Trial
    ../../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin/Libraries/NXP/Keil/: emWin_530_Keil_M3.lib
  group uEZ/Source/ExpansionBoard/FDI/uEZGUI_EXP
    ../../../../../../../uEZ/Source/ExpansionBoard/FDI/uEZGUI_EXP_DK/: uEZGUI_EXP_DK.c uEZGUI_EXP_DK.h
  group Platform/FDI/UEZGUI_1788_56VI
    ../../../../../../../uEZ/Source/Platform/FDI/uEZGUI_1788_56VI/: UEZPlatform.h uEZGUI_1788_56VI.c
target Debug-Trace (ARM-ADS)
  device: LPC1788 NXP
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: uEZGUI-1788-56VI +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: COMPILER_TYPE=Keil4, GCC_ARMCM3, DEBUG,FREERTOS_PLUS_TRACE
  c include: .;..\..\..\..\..\..\Source\App\uEZGUI;..\..\..\..\..\..\Source\App\uEZDemoCommon;..\..\..\..\..\..\Source\App\SEGGER\emWin\GUIDEMO;..\..\..\..\..\..\..\uEZ;..\..\..\..\..\..\..\uEZ\Include;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP\Include;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP\src\include;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP\src;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP\src\include\ipv4;..\..\..\..\..\..\..\uEZ\Source\RTOS\FreeRTOS\include;..\..\..\..\..\..\..\uEZ\Source\Platform\FDI\UEZGUI_1788_56VI;..\..\..\..\..\..\..\uEZ\Source\Processor\NXP\LPC17xx_40xx;..\..\..\..\..\..\..\uEZ\Source\Processor\NXP\LPC17xx_40xx\Keil4\include;..\..\..\..\..\..\..\uEZ\Source\Library\GUI\SEGGER\emWin;..\..\..\..\..\..\..\uEZ\Source\Platform\emWin\Inc;..\..\..\..\..\..\..\uEZ\Source\Platform\emWin\Config;..\..\..\..\..\..\..\uEZ\Source\RTOS\FreeRTOS-Plus\FreeRTOS-Plus-Trace\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\uEZGUI-1788-56VI-Trace.sct
  link misc: --verbose
target Release (ARM-ADS)
  device: LPC1788 NXP
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: uEZGUI-1788-56VI +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: COMPILER_TYPE=Keil4, GCC_ARMCM3
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\uEZGUI-1788-56VI.sct
  link misc: --verbose
software components: CMSIS:CORE 5.0.0
