<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\TestGainSpan-1788-56VI.ewp</path>
  </project>
  <batchBuild/>
</workspace>


