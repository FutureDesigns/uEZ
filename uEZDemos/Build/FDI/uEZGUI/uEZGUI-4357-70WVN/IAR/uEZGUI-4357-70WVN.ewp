# IAR project uEZGUI-4357-70WVN.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_M4; LWIP_2_0_x; DEBUG; __FPU_PRESENT=1
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: .; ../../../../../Source/App; ../../../../../Source/App/uEZGUI; ../../../../../Source/App/uEZDemoCommon; ../../../../../Source/App/SEGGER/emWin/GUIDEMO; ../../../../../../uEZ; ../../../../../../uEZ/Include; ../../../../../../uEZ/Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../../../uEZ/Source/Platform/FDI/uEZGUI_4357_70WVN; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/IAR/; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/Common/; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/Common/include; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/Common/include/CMSIS; ../../../../../../uEZ/Source/RTOS/FreeRTOS/include; ../../../../../../uEZ/Source/RTOS/FreeRTOS/; ../../../../../../uEZ/Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../../../uEZ/Source/Library/Encryption/mbedtls/include; ../../../../../../uEZ/Source/Library/Encryption/mbedtls; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/src/include; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/src; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/Include; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/src/include/ipv4; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/system; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/system/arch; ../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin; ../../../../../../uEZ/Source/Platform/emWin/Inc; ../../../../../../uEZ/Source/Platform/emWin/Config; ../../../../../../uEZ/Source/Library/LPCOpen/chip_18xx_43xx
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../../../../../../uEZ; ../../../../../../uEZ/Source/App/Demos/uEZGUI; ../../../../../../uEZ/Source/App/Demos/FDI/SEGGER/emWin/GUIDEMO; ../../../../../../uEZ/Source/Platform/FDI/uEZGUI_4357_70WVN; ../../../../../../uEZ/Source/Platform/emWin/; ../../../../../../uEZ/Source/Platform/emWin/Config; ../../../../../../uEZ/Source/Platform/emWin/Inc; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/IAR/; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/Common/; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/Common/include; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/Common/include/CMSIS; ../../../../../../uEZ/Include; ../../../../../../uEZ/Source/RTOS/FreeRTOS/include; ../../../../../../uEZ/Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/src/include; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/src; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/Include; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/src/include/ipv4; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/system; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/system/arch
  OBJCOPY.OOCOutputFile: uEZGUI-4357-70WVN.hex
  ILINK.IlinkOutputFile: uEZGUI-4357-70WVN.out
  ILINK.IlinkIcfFile: lpc4357_m4_SDRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: Config_Build.h lpc4357_m4_SDRAM.icf
    ../../../../../../uEZ/Build/Generic/NXP/LPC4357/FreeRTOS/IAR/Debug-Trace/Exe/: uEZ_NXP_LPC4357_FreeRTOS_IAR_Debug-Trace.a
    ../../../../../../uEZ/Build/Generic/NXP/LPC4357/FreeRTOS/IAR/Debug/Exe/: uEZ_NXP_LPC4357_FreeRTOS_IAR_Debug.a
    ../../../../../../uEZ/Build/Generic/NXP/LPC4357/FreeRTOS/IAR/Release/Exe/: uEZ_NXP_LPC4357_FreeRTOS_IAR_Release.a
  group Include
    ../../../../../../uEZ/Include/: Config.h fcntl.h FreeRTOSConfig.h Global.h signal.h uEZ.h uEZADC.h uEZCharDisplay.h uEZDevice.h uEZDeviceTable.h uEZErrors.h uEZFile.h uEZI2C.h uEZKeypad.h uEZLCD.h uEZLEDBank.h uEZMemory.h uEZProcessor.h uEZRTOS.h uEZSPI.h uEZStream.h uEZTemperature.h uEZTickCounter.h uEZTimeDate.h uEZToneGenerator.h uEZTS.h uEZTypes.h unistd.h
  group Include/Device
    ../../../../../../uEZ/Include/Device/: Accelerometer.h ADCBank.h Backlight.h ButtonBank.h CharDisplay.h EEPROM.h ExternalInterrupt.h FileSystem.h Flash.h I2CBus.h Keypad.h LCD.h LEDBank.h MassStorage.h PWM.h RTC.h SPIBus.h Stream.h Temperature.h ToneGenerator.h Touchscreen.h USBDevice.h USBHost.h
  group Include/Device/LCD
    ../../../../../../uEZ/Include/Device/LCD/: Config_LCD.h
  group Include/HAL
    ../../../../../../uEZ/Include/HAL/: ADCBank.h EMAC.h GPIO.h HAL.h I2CBus.h Interrupt.h LCDController.h PWM.h RTC.h Serial.h SPI.h Timer.h USBDeviceController.h USBHost.h Watchdog.h
  group Include/netinet
    ../../../../../../uEZ/Include/netinet/: in.h
  group Include/sys
    ../../../../../../uEZ/Include/sys/: mman.h socket.h stat.h time.h types.h
  group Include/Types
    ../../../../../../uEZ/Include/Types/: Accelerometer.h ADC.h EEPROM.h EMAC.h File.h Flash.h I2C.h InputEvent.h LCD.h Serial.h SPI.h TimeDate.h USBDevice.h USBHost.h
  group Source/App/SEGGER/emWin
    ../../../../../Source/App/SEGGER/emWin/: emWin.c
  group Source/App/SEGGER/emWin/GUIDEMO
    ../../../../../Source/App/SEGGER/emWin/GUIDEMO/: GUIDEMO.c GUIDEMO.h GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group Source/App/uEZDemoCommon
    ../../../../../Source/App/uEZDemoCommon/: AccelDemoMode.c App_RTOS.c AppHTTPServer.c AppHTTPServer.h AppMenu.c AppMenu.h Audio.c Audio.h AudioPlayer.h BrightnessControlMode.c Calibration.c Calibration.h CANTest.c ConsoleMode.c DrawMode.c FuncTestFramework.h FunctionalTest.c FunctionalTest.h FunctionalTest_EXP_DK.c FunctionalTest_EXP_DK.h FunctionalTestLoop.c MultiSlideshowMode.c NetworkStartup.c NetworkStartup.h NVSettings.c NVSettings.h SingleSlideshowMode.c SingleSlideshowMode.h Slideshow.h TempMode.c TestCmds.c TestCmds.h TestMode.c TimeDateMode.c UDCImages.c UDCImages.h uEZDemoCommon.h VideoPlayer.c VideoPlayer.h VideoPlayerSelection.c YourAppMode.c
  group Source/App/uEZGUI
    ../../../../../Source/App/uEZGUI/: AppDemo.h AppTasks.c AppTasks.h Config_App.h main.c MainMenu.c
  group Source/ExpansionBoard/FDI/uEZGUI_EXP_DK
    ../../../../../../uEZ/Source/ExpansionBoard/FDI/uEZGUI_EXP_DK/: uEZGUI_EXP_DK.c uEZGUI_EXP_DK.h
  group Source/Library/GUI/SEGGER/emWin
    ../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin/: BUTTON.h BUTTON_Private.h CHECKBOX.h CHECKBOX_Private.h DIALOG.h DIALOG_Intern.h DROPDOWN.h DROPDOWN_Private.h EDIT.h EDIT_Private.h FRAMEWIN.h FRAMEWIN_Private.h Global.h GRAPH.h GRAPH_Private.h GUI.h GUI_ARRAY.h GUI_ARRAY_Private.h GUI_BMP_Private.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_GIF_Private.h GUI_HOOK.h GUI_JPEG_Private.h GUI_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_Type.h GUI_Version.h GUI_VNC.h GUIDRV_07X1.h GUIDRV_13700.h GUIDRV_13748.h GUIDRV_1611.h GUIDRV_6331.h GUIDRV_7529.h GUIDRV_BitPlains.h GUIDRV_CompactColor_16.h GUIDRV_Fujitsu_16.h GUIDRV_Generic.h GUIDRV_GW7630_1.h GUIDRV_IST3088.h GUIDRV_IST3088_Private.h GUIDRV_L5F30919.h GUIDRV_Lin.h GUIDRV_Lin_Private.h GUIDRV_NoOpt_1_8.h GUIDRV_Page1bpp.h GUIDRV_S1D13748.h GUIDRV_S1D13748_Private.h GUIDRV_S1D13U11.h GUIDRV_S1D15G00.h GUIDRV_SLin.h GUIDRV_SLin_Private.h GUIDRV_SSD1926.h GUIDRV_SSD1926_Private.h GUIDRV_Template.h GUIDRV_TemplateI.h GUIDRV_TemplateI_Private.h GUIDRV_UC1698G4.h HEADER.h HEADER_Private.h ICONVIEW.h ICONVIEW_Private.h LCD.h LCD_ConfDefaults.h LCD_Private.h LCD_Protected.h LCD_SIM.h LISTBOX.h LISTBOX_Private.h LISTVIEW.h LISTVIEW_Private.h LISTWHEEL.h LISTWHEEL_Private.h MENU.h MENU_Private.h MESSAGEBOX.h MULTIEDIT.h MULTIPAGE.h MULTIPAGE_Private.h PROGBAR.h PROGBAR_Private.h RADIO.h RADIO_Private.h SCROLLBAR.h SCROLLBAR_Private.h SLIDER.h SLIDER_Private.h TEXT.h TEXT_Private.h TREEVIEW.h TREEVIEW_Private.h WIDGET.h WINDOW_Private.h WM.h WM_GUI.h WM_Intern.h WM_Intern_ConfDep.h
  group Source/Library/GUI/SEGGER/emWin/Library/NXP
    ../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin/Libraries/NXP/IAR/: emWin_IAR_M4F.a
  group Source/Platform/FDI/uEZGUI_4357_70WVN
    ../../../../../../uEZ/Source/Platform/FDI/uEZGUI_4357_70WVN/: uEZGUI_4357_70WVN.c uEZPlatform.h uEZPlatformTest.c
