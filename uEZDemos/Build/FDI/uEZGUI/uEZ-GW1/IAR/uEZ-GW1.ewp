# IAR project uEZ-GW1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: IAR_ARM_CM4F; CORE_M4
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: .; ../../../../../Source/App/uEZ_GW; ../../../../../Source/App/uEZ_GW/BLE; ../../../../../Source/App/uEZDemoCommon; ../../../../../Source/App/SEGGER/emWin/GUIDEMO; C:/Ubiquios/; C:/Ubiquios/include; ../../../../../../uEZ; ../../../../../../uEZ/Include; ../../../../../../uEZ/Source/Platform/FDI/uEZ_GW1; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/IAR/; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/Common/; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/Common/include; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/Common/include/CMSIS; ../../../../../../uEZ/Source/RTOS/FreeRTOS/include; ../../../../../../uEZ/Source/RTOS/FreeRTOS/; ../../../../../../uEZ/Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../../../uEZ/Source/Library/lwIP/src/include; ../../../../../../uEZ/Source/Library/lwIP/src; ../../../../../../uEZ/Source/Library/lwIP/Include; ../../../../../../uEZ/Source/Library/lwIP/src/include/ipv4; ../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin; ../../../../../../uEZ/Source/Platform/emWin/Inc; ../../../../../../uEZ/Source/Platform/emWin/Config; ../../../../../../uEZ/Source/Library/LPCOpen/chip_18xx_43xx
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../../../../../../uEZ; ../../../../../../uEZ/Source/App/Demos/uEZGUI; ../../../../../../uEZ/Source/App/Demos/FDI/SEGGER/emWin/GUIDEMO; ../../../../../../uEZ/Source/Platform/FDI/uEZ_GW1; ../../../../../../uEZ/Source/Platform/emWin/; ../../../../../../uEZ/Source/Platform/emWin/Config; ../../../../../../uEZ/Source/Platform/emWin/Inc; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/IAR/; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/Common/; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/Common/include; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/Common/include/CMSIS; ../../../../../../uEZ/Include; ../../../../../../uEZ/Source/RTOS/FreeRTOS/include; ../../../../../../uEZ/Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin; ../../../../../../uEZ/Source/Library/lwIP/src/include; ../../../../../../uEZ/Source/Library/lwIP/src; ../../../../../../uEZ/Source/Library/lwIP/Include; ../../../../../../uEZ/Source/Library/lwIP/src/include/ipv4
  OBJCOPY.OOCOutputFile: uEZ-GW1.hex
  ILINK.IlinkOutputFile: uEZ-GW1.out
  ILINK.IlinkIcfFile: lpc4357_m4_SDRAM.icf
  ILINK.IlinkAdditionalLibs: C:\Ubiquios\lib\libubiquios.a; C:\Ubiquios\lib\libubiquios_bt_bcm434x.a; C:\Ubiquios\lib\libubiquios_wlan_bcmfmac.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; IAR_ARM_CM4F; CORE_M4; LWIP_2_0_x
  ICCARM.CCIncludePath2: .; ../../../../../Source/App/uEZGUI; ../../../../../Source/App/uEZDemoCommon; ../../../../../Source/App/SEGGER/emWin/GUIDEMO; ../../../../../../uEZ; ../../../../../../uEZ/Include; ../../../../../../uEZ/Source/Platform/FDI/uEZ_GW1; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/IAR/; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/Common/; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/Common/include; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/Common/include/CMSIS; ../../../../../../uEZ/Source/RTOS/FreeRTOS/include; ../../../../../../uEZ/Source/RTOS/FreeRTOS/; ../../../../../../uEZ/Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/src/include; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/src; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/Include; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/src/include/ipv4; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/system; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/system/arch; ../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin; ../../../../../../uEZ/Source/Platform/emWin/Inc; ../../../../../../uEZ/Source/Platform/emWin/Config; ../../../../../../uEZ/Source/Library/LPCOpen/chip_18xx_43xx
  ICCARM.CCOptLevel: 2
  AARM.AUserIncludes: ../../../../../../uEZ; ../../../../../../uEZ/Source/App/Demos/uEZGUI; ../../../../../../uEZ/Source/App/Demos/FDI/SEGGER/emWin/GUIDEMO; ../../../../../../uEZ/Source/Platform/FDI/uEZ_GW1; ../../../../../../uEZ/Source/Platform/emWin/; ../../../../../../uEZ/Source/Platform/emWin/Config; ../../../../../../uEZ/Source/Platform/emWin/Inc; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/IAR/; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/Common/; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/Common/include; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/Common/include/CMSIS; ../../../../../../uEZ/Include; ../../../../../../uEZ/Source/RTOS/FreeRTOS/include; ../../../../../../uEZ/Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/src/include; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/src; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/Include; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/src/include/ipv4; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/system; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/system/arch
configuration Debug-Trace (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR_ARM_CM4F; CORE_M4; FREERTOS_PLUS_TRACE; LWIP_2_0_x
  ICCARM.CCIncludePath2: .; ../../../../../Source/App/uEZGUI; ../../../../../Source/App/uEZDemoCommon; ../../../../../Source/App/SEGGER/emWin/GUIDEMO; ../../../../../../uEZ; ../../../../../../uEZ/Include; ../../../../../../uEZ/Source/Platform/FDI/uEZ_GW1; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/IAR/; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/Common/; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/Common/include; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/Common/include/CMSIS; ../../../../../../uEZ/Source/RTOS/FreeRTOS/include; ../../../../../../uEZ/Source/RTOS/FreeRTOS/; ../../../../../../uEZ/Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../../../uEZ/Source/RTOS/FreeRTOS-Plus/FreeRTOS-Plus-Trace/include; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/src/include; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/src; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/Include; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/src/include/ipv4; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/system; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/system/arch; ../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin; ../../../../../../uEZ/Source/Platform/emWin/Inc; ../../../../../../uEZ/Source/Platform/emWin/Config; ../../../../../../uEZ/Source/Library/LPCOpen/chip_18xx_43xx
  AARM.AUserIncludes: as above
configuration Debug_Bootloader (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: .; ../../../../../Source/App/uEZ_GW; ../../../../../Source/App/uEZ_GW/BLE; ../../../../../Source/App/uEZDemoCommon; ../../../../../Source/App/SEGGER/emWin/GUIDEMO; C:/Ubiquios/; C:/Ubiquios/include; ../../../../../../uEZ; ../../../../../../uEZ/Include; ../../../../../../uEZ/Source/Platform/FDI/uEZ_GW1; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/IAR/include; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/IAR/include/CMSIS; ../../../../../../uEZ/Source/RTOS/FreeRTOS/include; ../../../../../../uEZ/Source/RTOS/FreeRTOS/; ../../../../../../uEZ/Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/src/include; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/src; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/Include; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/src/include/ipv4; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/system; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/system/arch; ../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin; ../../../../../../uEZ/Source/Platform/emWin/Inc; ../../../../../../uEZ/Source/Platform/emWin/Config; ../../../../../../uEZ/Source/Library/LPCOpen/chip_18xx_43xx
  AARM.AUserIncludes: ../../../../../../uEZ; ../../../../../../uEZ/Source/App/Demos/uEZGUI; ../../../../../../uEZ/Source/App/Demos/FDI/SEGGER/emWin/GUIDEMO; ../../../../../../uEZ/Source/Platform/FDI/uEZ_GW1; ../../../../../../uEZ/Source/Platform/emWin/; ../../../../../../uEZ/Source/Platform/emWin/Config; ../../../../../../uEZ/Source/Platform/emWin/Inc; ../../../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx; ../../../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx/IAR/; ../../../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx/Common/include; ../../../../../../uEZ/Include; ../../../../../../uEZ/Source/RTOS/FreeRTOS/include; ../../../../../../uEZ/Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/src/include; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/src; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/Include; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/src/include/ipv4; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/system; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/system/arch
  ILINK.IlinkIcfFile: uEZGUI_4357_Bootloader.icf
  group (top)
    ./: Config_Build.h lpc4357_m4_SDRAM.icf uEZGUI_4357_Bootloader.icf
    ../../../../../../uEZ/Build/Generic/NXP/LPC4357/FreeRTOS/IAR/Debug-Trace/Exe/: uEZ_NXP_LPC4357_FreeRTOS_IAR_Debug-Trace.a
    ../../../../../../uEZ/Build/Generic/NXP/LPC4357/FreeRTOS/IAR/Debug/Exe/: uEZ_NXP_LPC4357_FreeRTOS_IAR_Debug.a
    ../../../../../../uEZ/Build/Generic/NXP/LPC4357/FreeRTOS/IAR/Release/Exe/: uEZ_NXP_LPC4357_FreeRTOS_IAR_Release.a
  group Include
    ../../../../../../uEZ/Include/: Config.h fcntl.h FreeRTOSConfig.h signal.h uEZ.h uEZADC.h uEZCharDisplay.h uEZDevice.h uEZDeviceTable.h uEZErrors.h uEZFile.h uEZI2C.h uEZKeypad.h uEZLCD.h uEZLEDBank.h uEZMemory.h uEZProcessor.h uEZRTOS.h uEZSPI.h uEZStream.h uEZTemperature.h uEZTickCounter.h uEZTimeDate.h uEZToneGenerator.h uEZTS.h uEZTypes.h unistd.h
  group Include/Device
    ../../../../../../uEZ/Include/Device/: Accelerometer.h ADCBank.h Backlight.h ButtonBank.h CharDisplay.h EEPROM.h ExternalInterrupt.h FileSystem.h Flash.h I2CBus.h Keypad.h LCD.h LEDBank.h MassStorage.h PWM.h RTC.h SPIBus.h Stream.h Temperature.h ToneGenerator.h Touchscreen.h USBDevice.h USBHost.h
  group Include/Device/LCD
    ../../../../../../uEZ/Include/Device/LCD/: Config_LCD.h
  group Include/HAL
    ../../../../../../uEZ/Include/HAL/: ADCBank.h EMAC.h GPIO.h HAL.h I2CBus.h Interrupt.h LCDController.h PWM.h RTC.h Serial.h SPI.h Timer.h USBDeviceController.h USBHost.h Watchdog.h
  group Include/netinet
    ../../../../../../uEZ/Include/netinet/: in.h
  group Include/sys
    ../../../../../../uEZ/Include/sys/: mman.h socket.h stat.h time.h types.h
  group Include/Types
    ../../../../../../uEZ/Include/Types/: Accelerometer.h ADC.h EEPROM.h EMAC.h File.h Flash.h I2C.h InputEvent.h LCD.h Serial.h SPI.h TimeDate.h USBDevice.h USBHost.h
  group Source/App/uEZ_GW
    ../../../../../Source/App/uEZ_GW/: AppDemo.h AppTasks.c AppTasks.h Cell_Modem.c Cell_Modem.h Config_App.h Configuration_EEPROM.c Configuration_EEPROM.h FuncTestFramework.h FunctionalTest.c FunctionalTest.h FunctionalTestLoop.c main.c TestCmds.c TestCmds.h TestMode.c UbiquiOS_Test.c UbiquiOS_Test.h
  group Source/App/uEZ_GW/BLE
    ../../../../../Source/App/uEZ_GW/BLE/: apitypes.h BluegigaTest.c BluegigaTest.h cmd_def.c cmd_def.h commands.c stubs.c
  group Source/App/uEZDemoCommon
    ../../../../../Source/App/uEZDemoCommon/: AccelDemoMode.c AppHTTPServer.c AppHTTPServer.h Audio.c Audio.h AudioPlayer.h NetworkStartup.c NetworkStartup.h NVSettings.c NVSettings.h uEZDemoCommon.h
  group Source/ExpansionBoard/FDI/uEZGUI_EXP_DK
    ../../../../../../uEZ/Source/ExpansionBoard/FDI/uEZGUI_EXP_DK/: uEZGUI_EXP_DK.c uEZGUI_EXP_DK.h
  group Source/Library/GUI/SEGGER/emWin
    ../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin/: BUTTON.h BUTTON_Private.h CHECKBOX.h CHECKBOX_Private.h DIALOG.h DIALOG_Intern.h DROPDOWN.h DROPDOWN_Private.h EDIT.h EDIT_Private.h FRAMEWIN.h FRAMEWIN_Private.h Global.h GRAPH.h GRAPH_Private.h GUI.h GUI_ARRAY.h GUI_ARRAY_Private.h GUI_BMP_Private.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_GIF_Private.h GUI_HOOK.h GUI_JPEG_Private.h GUI_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_Type.h GUI_Version.h GUI_VNC.h GUIDRV_07X1.h GUIDRV_13700.h GUIDRV_13748.h GUIDRV_1611.h GUIDRV_6331.h GUIDRV_7529.h GUIDRV_BitPlains.h GUIDRV_CompactColor_16.h GUIDRV_Fujitsu_16.h GUIDRV_Generic.h GUIDRV_GW7630_1.h GUIDRV_IST3088.h GUIDRV_IST3088_Private.h GUIDRV_L5F30919.h GUIDRV_Lin.h GUIDRV_Lin_Private.h GUIDRV_NoOpt_1_8.h GUIDRV_Page1bpp.h GUIDRV_S1D13748.h GUIDRV_S1D13748_Private.h GUIDRV_S1D13U11.h GUIDRV_S1D15G00.h GUIDRV_SLin.h GUIDRV_SLin_Private.h GUIDRV_SSD1926.h GUIDRV_SSD1926_Private.h GUIDRV_Template.h GUIDRV_TemplateI.h GUIDRV_TemplateI_Private.h GUIDRV_UC1698G4.h HEADER.h HEADER_Private.h ICONVIEW.h ICONVIEW_Private.h LCD.h LCD_ConfDefaults.h LCD_Private.h LCD_Protected.h LCD_SIM.h LISTBOX.h LISTBOX_Private.h LISTVIEW.h LISTVIEW_Private.h LISTWHEEL.h LISTWHEEL_Private.h MENU.h MENU_Private.h MESSAGEBOX.h MULTIEDIT.h MULTIPAGE.h MULTIPAGE_Private.h PROGBAR.h PROGBAR_Private.h RADIO.h RADIO_Private.h SCROLLBAR.h SCROLLBAR_Private.h SLIDER.h SLIDER_Private.h TEXT.h TEXT_Private.h TREEVIEW.h TREEVIEW_Private.h WIDGET.h WINDOW_Private.h WM.h WM_GUI.h WM_Intern.h WM_Intern_ConfDep.h
  group Source/Library/GUI/SEGGER/emWin/Library/NXP
    ../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin/Libraries/NXP/IAR/: emwin_548_IAR_M4F.a
  group Source/Platform/FDI/uEZ_GW1
    ../../../../../../uEZ/Source/Platform/FDI/uEZ_GW1/: uEZ_GW1.c uEZPlatform.h
  group Source/Ubiquios/hal
    ../../../../../Source/Ubiquios/hal/: bt_bcm434x_hal.c debug_hal.c time_hal.c ub_bt_hal_bcm434x_hcd_file.c ub_cell_hal.c wlan_bcm_gspi_hal.c
  group Source/Ubiquios/include
    C:/Ubiquios/include/: ub_bignum.h ub_brofs.h ub_bt.h ub_bt_bcm434x.h ub_bt_csr.h ub_bt_generic_h4.h ub_bt_hal_bcm434x.h ub_bt_hal_csr_bcsp.h ub_bt_hal_generic_h4.h ub_bt_hal_h4.h ub_bt_hal_h5.h ub_bt_hal_ti_hcill.h ub_bt_ti_wl18xx.h ub_bt_uuids.h ub_cellular.h ub_cellular_hal.h ub_cipher.h ub_coex.h ub_common.h ub_country.h ub_debug_hal.h ub_dh.h ub_dns.h ub_dns_server.h ub_ecc.h ub_ethernet.h ub_ethernet_hal.h ub_generictcpclient.h ub_hash.h ub_hash_hmac.h ub_http_client.h ub_http_common.h ub_http_server.h ub_iothub.h ub_iperf.h ub_json.h ub_keystore.h ub_mac.h ub_main.h ub_main_hal.h ub_math.h ub_mime.h ub_mqtt.h ub_network.h ub_ntp.h ub_pktbuf.h ub_platform.h ub_pmalloc.h ub_pmalloc_backend.h ub_ppp.h ub_random.h ub_ringbuf.h ub_rsa.h ub_softkeystore.h ub_streambuf.h ub_strtok.h ub_tcpip.h ub_time.h ub_time_hal.h ub_timer.h ub_tls.h ub_to136.h ub_to136_hal.h ub_upnp.h ub_userconfig.h ub_ustdio.h ub_ute.h ub_ute_hal.h ub_ute_namespaces.h ub_utils.h ub_wlan.h ub_wlan_bcmfmac.h ub_wlan_csr.h ub_wlan_hal_bcm_gspi.h ub_wlan_hal_bcm_sdio.h ub_wlan_hal_csr_cspi.h ub_wlan_hal_ti_wspi.h ub_wlan_ti_wl18xx.h ub_zeroconf.h ubiquios.h ubiquios_bt_bcm434x.h ubiquios_bt_csrhci.h ubiquios_bt_generic_h4.h ubiquios_bt_ti_wl18xx.h ubiquios_wlan_bcmfmac.h ubiquios_wlan_bcmfmac_sdio.h ubiquios_wlan_csr6030a10.h ubiquios_wlan_csr6030a11.h ubiquios_wlan_ti_wl18xx.h
