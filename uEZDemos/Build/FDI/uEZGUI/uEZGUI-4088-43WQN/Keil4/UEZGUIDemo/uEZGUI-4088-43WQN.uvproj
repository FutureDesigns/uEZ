# Keil uVision project uEZGUI-4088-43WQN.uvproj, settings and files
target Debug (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: uEZGUI-4088-43WQN +hex
  c flags: Optim=1 wLevel=1
  c define: COMPILER_TYPE=Keil4, GCC_ARMCM4F, DEBUG
  c include: .;..\..\..\..\..\..\Source\App\uEZGUI;..\..\..\..\..\..\Source\App\uEZDemoCommon;..\..\..\..\..\..\Source\App\SEGGER\emWin\GUIDEMO;..\..\..\..\..\..\..\uEZ;..\..\..\..\..\..\..\uEZ\Include;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP\Include;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP\src\include;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP\src;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP\src\include\ipv4;..\..\..\..\..\..\..\uEZ\Source\RTOS\FreeRTOS\include;..\..\..\..\..\..\..\uEZ\Source\Platform\FDI\UEZGUI_4088_43WQN;..\..\..\..\..\..\..\uEZ\Source\Processor\NXP\LPC17xx_40xx;..\..\..\..\..\..\..\uEZ\Source\Processor\NXP\LPC17xx_40xx\Keil4\include;..\..\..\..\..\..\..\uEZ\Source\Library\GUI\SEGGER\emWin;..\..\..\..\..\..\..\uEZ\Source\Platform\emWin\Inc;..\..\..\..\..\..\..\uEZ\Source\Platform\emWin\Config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\uEZGUI-4088-43WQN.sct
  link misc: --verbose
  group Build
    ./: Config_Build.h
  group uEZGUI
    ../../../../../../Source/App/uEZGUI/: AppTasks.c FunctionalTest.c main.c MainMenu.c TestCmds.c TestMode.c AppDemo.h AppTasks.h Config_App.h FuncTestFramework.h FunctionalTest.h TestCmds.h FunctionalTest_EXP_DK.c FunctionalTest_EXP_DK.h FunctionalTestLoop.c
  group uEZDemoCommon
    ../../../../../../Source/App/uEZDemoCommon/: AccelDemoMode.c AppMenu.c AppMenu.h Audio.c Audio.h AudioPlayer.h BrightnessControlMode.c Calibration.c Calibration.h ConsoleMode.c DrawMode.c MultiSlideshowMode.c NVSettings.c NVSettings.h SingleSlideshowMode.c SingleSlideshowMode.h Slideshow.h TempMode.c TimeDateMode.c UDCImages.c UDCImages.h uEZDemoCommon.h YourAppMode.c VideoPlayer.c VideoPlayerSelection.c AppHTTPServer.c AppHTTPServer.h NetworkStartup.c CANTest.c
  group SEGGER/emWin
    ../../../../../../Source/App/SEGGER/emWin/: emWin.c
  group SEGGER/emWin/GUIDEMO
    ../../../../../../Source/App/SEGGER/emWin/GUIDEMO/: GUIDEMO.c GUIDEMO_Automotive.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group Library
    ../../../../../../../uEZ/Build/Generic/NXP/LPC4088/FreeRTOS/Keil4.x/Debug/: uEZ_NXP_LPC4088_FreeRTOS_Keil_Debug.lib
    ../../../../../../../uEZ/Build/Generic/NXP/LPC4088/FreeRTOS/Keil4.x/Debug-Trace/: uEZ_NXP_LPC4088_FreeRTOS_Keil_Debug-Trace.lib
    ../../../../../../../uEZ/Build/Generic/NXP/LPC4088/FreeRTOS/Keil4.x/Release/: uEZ_NXP_LPC4088_FreeRTOS_Keil_Release.lib
  group Include
    ../../../../Include/: Config.h
  group Platform/FDI/UEZGUI_4088_43WQN
    ../../../../../../../uEZ/Source/Platform/FDI/uEZGUI_4088_43WQN/: uEZGUI_4088_43WQN.c
  group Library/Segger/emWin
    ../../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin/Libraries/NXP/Keil/: emWin_522_Keil_M4.lib
  group uEZ/Source/ExpansionBoard/FDI/uEZGUI_EXP
    ../../../../../../../uEZ/Source/ExpansionBoard/FDI/uEZGUI_EXP_DK/: uEZGUI_EXP_DK.c uEZGUI_EXP_DK.h
target Debug-Trace (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: as above
  output: uEZGUI-4088-43WQN +hex
  c flags: Optim=1 wLevel=1
  c define: COMPILER_TYPE=Keil4, GCC_ARMCM4F, DEBUG, FREERTOS_PLUS_TRACE
  c include: .;..\..\..\..\..\..\Source\App\uEZGUI;..\..\..\..\..\..\Source\App\uEZDemoCommon;..\..\..\..\..\..\Source\App\SEGGER\emWin\GUIDEMO;..\..\..\..\..\..\..\uEZ;..\..\..\..\..\..\..\uEZ\Include;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP\Include;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP\src\include;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP\src;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP\src\include\ipv4;..\..\..\..\..\..\..\uEZ\Source\RTOS\FreeRTOS\include;..\..\..\..\..\..\..\uEZ\Source\Platform\FDI\UEZGUI_1788_43WQR;..\..\..\..\..\..\..\uEZ\Source\Processor\NXP\LPC17xx_40xx;..\..\..\..\..\..\..\uEZ\Source\Processor\NXP\LPC17xx_40xx\Keil4\include;..\..\..\..\..\..\..\uEZ\Source\Library\GUI\SEGGER\emWin;..\..\..\..\..\..\..\uEZ\Source\Platform\emWin\Inc;..\..\..\..\..\..\..\uEZ\Source\Platform\emWin\Config;..\..\..\..\..\..\..\uEZ\Source\RTOS\FreeRTOS-Plus\FreeRTOS-Plus-Trace\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\uEZGUI-4088-43WQN-Trace.sct
  link misc: --verbose
target Release (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: as above
  output: uEZGUI-4088-43WQN +hex
  c flags: Optim=1 wLevel=1
  c define: COMPILER_TYPE=Keil4, GCC_ARMCM4F
  c include: .;..\..\..\..\..\..\Source\App\uEZGUI;..\..\..\..\..\..\Source\App\uEZDemoCommon;..\..\..\..\..\..\Source\App\SEGGER\emWin\GUIDEMO;..\..\..\..\..\..\..\uEZ;..\..\..\..\..\..\..\uEZ\Include;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP\Include;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP\src\include;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP\src;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP\src\include\ipv4;..\..\..\..\..\..\..\uEZ\Source\RTOS\FreeRTOS\include;..\..\..\..\..\..\..\uEZ\Source\Platform\FDI\UEZGUI_1788_43WQR;..\..\..\..\..\..\..\uEZ\Source\Processor\NXP\LPC17xx_40xx;..\..\..\..\..\..\..\uEZ\Source\Processor\NXP\LPC17xx_40xx\Keil4\include;..\..\..\..\..\..\..\uEZ\Source\Library\GUI\SEGGER\emWin;..\..\..\..\..\..\..\uEZ\Source\Platform\emWin\Inc;..\..\..\..\..\..\..\uEZ\Source\Platform\emWin\Config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\uEZGUI-4088-43WQN.sct
  link misc: --verbose
