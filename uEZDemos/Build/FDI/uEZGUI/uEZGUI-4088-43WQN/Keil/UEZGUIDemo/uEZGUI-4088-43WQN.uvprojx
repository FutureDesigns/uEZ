# Keil uVision project uEZGUI-4088-43WQN.uvprojx, settings and files
target Debug (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.0.0
  cpu: IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uEZGUI-4088-43WQN +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: COMPILER_TYPE=Keil4, GCC_ARMCM4F, DEBUG
  c include: .;..\..\..\..\..\..\Source\App\uEZGUI;..\..\..\..\..\..\Source\App\uEZDemoCommon;..\..\..\..\..\..\Source\App\SEGGER\emWin\GUIDEMO;..\..\..\..\..\..\..\uEZ;..\..\..\..\..\..\..\uEZ\Include;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP\Include;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP\src\include;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP\src;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP\src\include\ipv4;..\..\..\..\..\..\..\uEZ\Source\RTOS\FreeRTOS\include;..\..\..\..\..\..\..\uEZ\Source\Platform\FDI\UEZGUI_4088_43WQN;..\..\..\..\..\..\..\uEZ\Source\Processor\NXP\LPC17xx_40xx;..\..\..\..\..\..\..\uEZ\Source\Processor\NXP\LPC17xx_40xx\Keil4\include;..\..\..\..\..\..\..\uEZ\Source\Library\GUI\SEGGER\emWin;..\..\..\..\..\..\..\uEZ\Source\Platform\emWin\Inc;..\..\..\..\..\..\..\uEZ\Source\Platform\emWin\Config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\uEZGUI-4088-43WQN.sct
  link misc: --verbose
  group Build
    ./: Config_Build.h
  group uEZGUI
    ../../../../../../Source/App/uEZGUI/: AppTasks.c FunctionalTest.c main.c MainMenu.c TestCmds.c TestMode.c AppDemo.h AppTasks.h Config_App.h FuncTestFramework.h FunctionalTest.h TestCmds.h FunctionalTest_EXP_DK.c FunctionalTest_EXP_DK.h FunctionalTestLoop.c
  group uEZDemoCommon
    ../../../../../../Source/App/uEZDemoCommon/: AccelDemoMode.c AppMenu.c AppMenu.h Audio.c Audio.h AudioPlayer.h BrightnessControlMode.c Calibration.c Calibration.h ConsoleMode.c DrawMode.c MultiSlideshowMode.c NVSettings.c NVSettings.h SingleSlideshowMode.c SingleSlideshowMode.h Slideshow.h TempMode.c TimeDateMode.c UDCImages.c UDCImages.h uEZDemoCommon.h YourAppMode.c VideoPlayer.c VideoPlayerSelection.c AppHTTPServer.c AppHTTPServer.h NetworkStartup.c CANTest.c
  group SEGGER/emWin
    ../../../../../../Source/App/SEGGER/emWin/: emWin.c
  group SEGGER/emWin/GUIDEMO
    ../../../../../../Source/App/SEGGER/emWin/GUIDEMO/: GUIDEMO.c GUIDEMO_Automotive.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c GUIDEMO_Conf.c GUIDEMO_AntialiasedText.c GUIDEMO_BarGraph.c
  group Library
    ../../../../../../../uEZ/Build/Generic/NXP/LPC4088/FreeRTOS/Keil/Debug/: uEZ_NXP_LPC4088_FreeRTOS_Keil_Debug.lib
    ../../../../../../../uEZ/Build/Generic/NXP/LPC4088/FreeRTOS/Keil/Debug-Trace/: uEZ_NXP_LPC4088_FreeRTOS_Keil_Debug-Trace.lib
    ../../../../../../../uEZ/Build/Generic/NXP/LPC4088/FreeRTOS/Keil/Release/: uEZ_NXP_LPC4088_FreeRTOS_Keil_Release.lib
  group Include
    ../../../../Include/: Config.h
  group Platform/FDI/UEZGUI_4088_43WQN
    ../../../../../../../uEZ/Source/Platform/FDI/uEZGUI_4088_43WQN/: uEZGUI_4088_43WQN.c
  group Library/Segger/emWin
    ../../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin/Libraries/NXP/Keil/: emWin_530_Keil_M4F.lib
  group uEZ/Source/ExpansionBoard/FDI/uEZGUI_EXP
    ../../../../../../../uEZ/Source/ExpansionBoard/FDI/uEZGUI_EXP_DK/: uEZGUI_EXP_DK.c uEZGUI_EXP_DK.h
target Release (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.0.0
  cpu: as above
  output: uEZGUI-4088-43WQN +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: COMPILER_TYPE=Keil4, GCC_ARMCM4F
  c include: .;..\..\..\..\..\..\Source\App\uEZGUI;..\..\..\..\..\..\Source\App\uEZDemoCommon;..\..\..\..\..\..\Source\App\SEGGER\emWin\GUIDEMO;..\..\..\..\..\..\..\uEZ;..\..\..\..\..\..\..\uEZ\Include;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP\Include;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP\src\include;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP\src;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP\src\include\ipv4;..\..\..\..\..\..\..\uEZ\Source\RTOS\FreeRTOS\include;..\..\..\..\..\..\..\uEZ\Source\Platform\FDI\UEZGUI_1788_43WQR;..\..\..\..\..\..\..\uEZ\Source\Processor\NXP\LPC17xx_40xx;..\..\..\..\..\..\..\uEZ\Source\Processor\NXP\LPC17xx_40xx\Keil4\include;..\..\..\..\..\..\..\uEZ\Source\Library\GUI\SEGGER\emWin;..\..\..\..\..\..\..\uEZ\Source\Platform\emWin\Inc;..\..\..\..\..\..\..\uEZ\Source\Platform\emWin\Config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\uEZGUI-4088-43WQN.sct
  link misc: --verbose
target Debug-Trace (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.0.0
  cpu: as above
  output: uEZGUI-4088-43WQN +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: COMPILER_TYPE=Keil4, GCC_ARMCM4F, DEBUG, FREERTOS_PLUS_TRACE
  c include: .;..\..\..\..\..\..\Source\App\uEZGUI;..\..\..\..\..\..\Source\App\uEZDemoCommon;..\..\..\..\..\..\Source\App\SEGGER\emWin\GUIDEMO;..\..\..\..\..\..\..\uEZ;..\..\..\..\..\..\..\uEZ\Include;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP\Include;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP\src\include;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP\src;..\..\..\..\..\..\..\uEZ\Source\Library\lwIP\src\include\ipv4;..\..\..\..\..\..\..\uEZ\Source\RTOS\FreeRTOS\include;..\..\..\..\..\..\..\uEZ\Source\Platform\FDI\UEZGUI_4088_43WQN;..\..\..\..\..\..\..\uEZ\Source\Processor\NXP\LPC17xx_40xx;..\..\..\..\..\..\..\uEZ\Source\Processor\NXP\LPC17xx_40xx\Keil4\include;..\..\..\..\..\..\..\uEZ\Source\Library\GUI\SEGGER\emWin;..\..\..\..\..\..\..\uEZ\Source\Platform\emWin\Inc;..\..\..\..\..\..\..\uEZ\Source\Platform\emWin\Config;..\..\..\..\..\..\..\uEZ\Source\RTOS\FreeRTOS-Plus\FreeRTOS-Plus-Trace\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\uEZGUI-4088-43WQN.sct
  link misc: --verbose
software components: CMSIS:CORE 5.0.0
