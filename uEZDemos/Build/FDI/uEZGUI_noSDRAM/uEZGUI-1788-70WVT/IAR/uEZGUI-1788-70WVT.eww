<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\noSDRAM-1788-70WVT.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>noSDRAM-1788-70WVT</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>noSDRAM-1788-70WVT</project>
        <configuration>Debug-Trace</configuration>
      </member>
      <member>
        <project>noSDRAM-1788-70WVT</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


