# IAR project noSDRAM-1788-56VI.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CORE_M3; DEBUG
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: .; ../../../../../Source/App/uEZGUI_noSDRAM; ../../../../../Source/App/uEZDemoCommon; ../../../../../Source/App/SEGGER/emWin/GUIDEMO; ../../../../../../uEZ; ../../../../../../uEZ/Include; ../../../../../../uEZ/Source/Platform/FDI/uEZGUI_1788_56VI; ../../../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx; ../../../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx/IAR/; ../../../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx/Common/include; ../../../../../../uEZ/Source/Processor/ARM/CMSIS/Include; ../../../../../../uEZ/Source/Processor/ARM/DSP/Include; ../../../../../../uEZ/Source/RTOS/FreeRTOS/include; ..\..\..\..\..\..\uEZ\Source\RTOS\FreeRTOS\portable\IAR\ARM_CM3; ../../../../../../uEZ/Source/Library/Encryption/mbedtls/include; ../../../../../../uEZ/Source/Library/Encryption/mbedtls; ../../../../../../uEZ/Source/Library/lwIP/src/include; ../../../../../../uEZ/Source/Library/lwIP/src; ../../../../../../uEZ/Source/Library/lwIP/Include; ../../../../../../uEZ/Source/Library/lwIP/src/include/ipv4; ../../../../../../uEZ/Source/Library/lwIP/system; ../../../../../../uEZ/Source/Library/lwIP/system/arch; ../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin; ../../../../../../uEZ/Source/Platform/emWin/Inc; ../../../../../../uEZ/Source/Platform/emWin/Config
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../../../../../../uEZ; ../../../../../../uEZ/Source/App/Demos/uEZGUI; ../../../../../../uEZ/Source/App/Demos/FDI/SEGGER/emWin/GUIDEMO; ../../../../../../uEZ/Source/Platform/FDI/uEZGUI_1788_56VI; ../../../../../../uEZ/Source/Platform/emWin/; ../../../../../../uEZ/Source/Platform/emWin/Config; ../../../../../../uEZ/Source/Platform/emWin/Inc; ../../../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx; ../../../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx/IAR/; ../../../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx/Common/include; ../../../../../../uEZ/Source/Processor/ARM/CMSIS/Include; ../../../../../../uEZ/Source/Processor/ARM/DSP/Include; ../../../../../../uEZ/Include; ../../../../../../uEZ/Source/RTOS/FreeRTOS/include; G:\FDI\uEZ\TrunkOnly\uEZ\Source\RTOS\FreeRTOS\portable\IAR\ARM_CM3; ../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin; ../../../../../../uEZ/Source/Library/lwIP/src/include; ../../../../../../uEZ/Source/Library/lwIP/src; ../../../../../../uEZ/Source/Library/lwIP/Include; ../../../../../../uEZ/Source/Library/lwIP/src/include/ipv4; ../../../../../../uEZ/Source/Library/lwIP/system; ../../../../../../uEZ/Source/Library/lwIP/system/arch
  OBJCOPY.OOCOutputFile: noSDRAM-1788-56VI.hex
  ILINK.IlinkOutputFile: uEZGUI-1788-43WQR.out
  ILINK.IlinkIcfFile: uEZGUI_1788.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: Config_Build.h uEZGUI_1788.icf
    ../../../../../../uEZ/Build/Generic/NXP/LPC1788/FreeRTOS/IAR/Debug-Trace/Exe/: uEZ_NXP_LPC1788_FreeRTOS_IAR_Debug-Trace.a
    ../../../../../../uEZ/Build/Generic/NXP/LPC1788/FreeRTOS/IAR/Debug/Exe/: uEZ_NXP_LPC1788_FreeRTOS_IAR_Debug.a
    ../../../../../../uEZ/Build/Generic/NXP/LPC1788/FreeRTOS/IAR/Release/Exe/: uEZ_NXP_LPC1788_FreeRTOS_IAR_Release.a
  group flash_loader
    flash_loader/: LPC177x_8x.mac uEZGUI_1788_70WVE.flash
    ../../../../../Utilities/Flashloader/uEZGUI_1788/flash_loader/: uEZGUI_1788.board
  group flash_loader NOR
    flash_loader NOR/: LPC177x_8x.mac uEZGUI_1788_70WVE_NOR.board uEZGUI_1788_70WVE_NOR.flash uEZGUI_1788_NOR.icf
  group Include
    ../../../../../../uEZ/Include/: Config.h fcntl.h FreeRTOSConfig.h signal.h uEZ.h uEZADC.h uEZCharDisplay.h uEZDevice.h uEZDeviceTable.h uEZErrors.h uEZFile.h uEZI2C.h uEZKeypad.h uEZLCD.h uEZLEDBank.h uEZMemory.h uEZProcessor.h uEZRTOS.h uEZSPI.h uEZStream.h uEZTemperature.h uEZTickCounter.h uEZTimeDate.h uEZToneGenerator.h uEZTS.h uEZTypes.h unistd.h
  group Include/Device
    ../../../../../../uEZ/Include/Device/: Accelerometer.h ADCBank.h Backlight.h ButtonBank.h CharDisplay.h EEPROM.h ExternalInterrupt.h FileSystem.h Flash.h I2CBus.h Keypad.h LCD.h LEDBank.h MassStorage.h PWM.h RTC.h SPIBus.h Stream.h Temperature.h ToneGenerator.h Touchscreen.h USBDevice.h USBHost.h
  group Include/Device/LCD
    ../../../../../../uEZ/Include/Device/LCD/: Config_LCD.h
  group Include/HAL
    ../../../../../../uEZ/Include/HAL/: ADCBank.h EMAC.h GPIO.h HAL.h I2CBus.h Interrupt.h LCDController.h PWM.h RTC.h Serial.h SPI.h Timer.h USBDeviceController.h USBHost.h Watchdog.h
  group Include/netinet
    ../../../../../../uEZ/Include/netinet/: in.h
  group Include/sys
    ../../../../../../uEZ/Include/sys/: mman.h socket.h stat.h time.h types.h
  group Include/Types
    ../../../../../../uEZ/Include/Types/: Accelerometer.h ADC.h EEPROM.h EMAC.h File.h Flash.h I2C.h InputEvent.h LCD.h Serial.h SPI.h TimeDate.h USBDevice.h USBHost.h
  group Source/App/uEZDemoCommon
    ../../../../../Source/App/uEZDemoCommon/: App_RTOS.c Audio.c Audio.h FuncTestFramework.h FunctionalTest.c FunctionalTest.h FunctionalTest_EXP_DK.c FunctionalTest_EXP_DK.h FunctionalTestLoop.c NetworkStartup.c NetworkStartup.h NVSettings.c NVSettings.h TestCmds.c TestCmds.h TestMode.c YourAppMode.c
  group Source/App/uEZGUI_noSDRAM
    ../../../../../Source/App/uEZGUI_noSDRAM/: AppDemo.h AppTasks.c AppTasks.h Config_App.h main.c
  group Source/ExpansionBoard/FDI/uEZGUI_EXP_DK
    ../../../../../../uEZ/Source/ExpansionBoard/FDI/uEZGUI_EXP_DK/: uEZGUI_EXP_DK.c uEZGUI_EXP_DK.h
  group Source/Platform/FDI/uEZGUI_1788_56VI
    ../../../../../../uEZ/Source/Platform/FDI/uEZGUI_1788_56VI/: lwipopts.h uEZGUI_1788_56VI.c uEZPlatform.h uEZPlatformTest.c
