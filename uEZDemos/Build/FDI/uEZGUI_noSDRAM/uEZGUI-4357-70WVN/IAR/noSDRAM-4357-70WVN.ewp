# IAR project noSDRAM-4357-70WVN.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_M4; LWIP_2_0_x; DEBUG; __FPU_PRESENT=1
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: .; ../../../../../Source/App/uEZGUI_noSDRAM; ../../../../../Source/App/uEZDemoCommon; ../../../../../Source/App/SEGGER/emWin/GUIDEMO; ../../../../../../uEZ; ../../../../../../uEZ/Include; ../../../../../../uEZ/Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../../../uEZ/Source/Platform/FDI/uEZGUI_4357_70WVN; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/IAR/; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/Common/; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/Common/include; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/Common/include/CMSIS; ../../../../../../uEZ/Source/RTOS/FreeRTOS/include; ../../../../../../uEZ/Source/RTOS/FreeRTOS/; ../../../../../../uEZ/Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../../../uEZ/Source/Library/Encryption/mbedtls/include; ../../../../../../uEZ/Source/Library/Encryption/mbedtls; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/src/include; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/src; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/Include; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/src/include/ipv4; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/system; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/system/arch; ../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin; ../../../../../../uEZ/Source/Platform/emWin/Inc; ../../../../../../uEZ/Source/Platform/emWin/Config; ../../../../../../uEZ/Source/Library/LPCOpen/chip_18xx_43xx
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../../../../../../uEZ; ../../../../../../uEZ/Source/App/Demos/uEZGUI; ../../../../../../uEZ/Source/App/Demos/FDI/SEGGER/emWin/GUIDEMO; ../../../../../../uEZ/Source/Platform/FDI/uEZGUI_4357_70WVN; ../../../../../../uEZ/Source/Platform/emWin/; ../../../../../../uEZ/Source/Platform/emWin/Config; ../../../../../../uEZ/Source/Platform/emWin/Inc; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/IAR/; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/Common/; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/Common/include; ../../../../../../uEZ/Source/Processor/NXP/LPC43xx/Common/include/CMSIS; ../../../../../../uEZ/Include; ../../../../../../uEZ/Source/RTOS/FreeRTOS/include; ../../../../../../uEZ/Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/src/include; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/src; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/Include; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/src/include/ipv4; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/system; ../../../../../../uEZ/Source/Library/lwIP_2.0.x/system/arch
  OBJCOPY.OOCOutputFile: uEZGUI-4357-70WVN.hex
  ILINK.IlinkOutputFile: uEZGUI-4357-70WVN.out
  ILINK.IlinkIcfFile: lpc4357_m4_SDRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: Config_Build.h lpc4357_m4_SDRAM.icf
    ../../../../../../uEZ/Build/Generic/NXP/LPC4357/FreeRTOS/IAR/Debug-Trace/Exe/: uEZ_NXP_LPC4357_FreeRTOS_IAR_Debug-Trace.a
    ../../../../../../uEZ/Build/Generic/NXP/LPC4357/FreeRTOS/IAR/Debug/Exe/: uEZ_NXP_LPC4357_FreeRTOS_IAR_Debug.a
    ../../../../../../uEZ/Build/Generic/NXP/LPC4357/FreeRTOS/IAR/Release/Exe/: uEZ_NXP_LPC4357_FreeRTOS_IAR_Release.a
  group Include
    ../../../../../../uEZ/Include/: Config.h fcntl.h FreeRTOSConfig.h Global.h signal.h uEZ.h uEZADC.h uEZCharDisplay.h uEZDevice.h uEZDeviceTable.h uEZErrors.h uEZFile.h uEZI2C.h uEZKeypad.h uEZLCD.h uEZLEDBank.h uEZMemory.h uEZProcessor.h uEZRTOS.h uEZSPI.h uEZStream.h uEZTemperature.h uEZTickCounter.h uEZTimeDate.h uEZToneGenerator.h uEZTS.h uEZTypes.h unistd.h
  group Include/Device
    ../../../../../../uEZ/Include/Device/: Accelerometer.h ADCBank.h Backlight.h ButtonBank.h CharDisplay.h EEPROM.h ExternalInterrupt.h FileSystem.h Flash.h I2CBus.h Keypad.h LCD.h LEDBank.h MassStorage.h PWM.h RTC.h SPIBus.h Stream.h Temperature.h ToneGenerator.h Touchscreen.h USBDevice.h USBHost.h
  group Include/Device/LCD
    ../../../../../../uEZ/Include/Device/LCD/: Config_LCD.h
  group Include/HAL
    ../../../../../../uEZ/Include/HAL/: ADCBank.h EMAC.h GPIO.h HAL.h I2CBus.h Interrupt.h LCDController.h PWM.h RTC.h Serial.h SPI.h Timer.h USBDeviceController.h USBHost.h Watchdog.h
  group Include/netinet
    ../../../../../../uEZ/Include/netinet/: in.h
  group Include/sys
    ../../../../../../uEZ/Include/sys/: mman.h socket.h stat.h time.h types.h
  group Include/Types
    ../../../../../../uEZ/Include/Types/: Accelerometer.h ADC.h EEPROM.h EMAC.h File.h Flash.h I2C.h InputEvent.h LCD.h Serial.h SPI.h TimeDate.h USBDevice.h USBHost.h
  group Source/App/uEZDemoCommon
    ../../../../../Source/App/uEZDemoCommon/: App_RTOS.c Audio.c Audio.h FuncTestFramework.h FunctionalTest.c FunctionalTest.h FunctionalTest_EXP_DK.c FunctionalTest_EXP_DK.h FunctionalTestLoop.c NetworkStartup.c NetworkStartup.h NVSettings.c NVSettings.h TestCmds.c TestCmds.h TestMode.c YourAppMode.c
  group Source/App/uEZGUI_noSDRAM
    ../../../../../Source/App/uEZGUI_noSDRAM/: AppDemo.h AppTasks.c AppTasks.h Config_App.h main.c
  group Source/ExpansionBoard/FDI/uEZGUI_EXP_DK
    ../../../../../../uEZ/Source/ExpansionBoard/FDI/uEZGUI_EXP_DK/: uEZGUI_EXP_DK.c uEZGUI_EXP_DK.h
  group Source/Platform/FDI/uEZGUI_4357_70WVN
    ../../../../../../uEZ/Source/Platform/FDI/uEZGUI_4357_70WVN/: uEZGUI_4357_70WVN.c uEZPlatform.h uEZPlatformTest.c
