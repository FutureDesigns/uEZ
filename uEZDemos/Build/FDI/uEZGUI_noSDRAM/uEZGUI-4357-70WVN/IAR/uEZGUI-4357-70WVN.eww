<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\noSDRAM-4357-70WVN.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>noSDRAM-4357-70WVN</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>noSDRAM-4357-70WVN</project>
        <configuration>Debug-Trace</configuration>
      </member>
      <member>
        <project>noSDRAM-4357-70WVN</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


