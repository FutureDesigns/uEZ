<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\uEZGUI-1788-70WVT.ewp</path>
  </project>
  <batchBuild/>
</workspace>


