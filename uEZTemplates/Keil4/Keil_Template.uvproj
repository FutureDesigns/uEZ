# Keil uVision project Keil_Template.uvproj, settings and files
target Debug (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Keil_Template +hex
  c flags: Optim=1 wLevel=1
  c define: COMPILER_TYPE=Keil4, GCC_ARMCM3, DEBUG
  c include: .;.\Source;..\..\uEZ;..\..\uEZ\Include;..\..\uEZ\Source\RTOS\FreeRTOS\include;..\..\uEZ\Source\Processor\NXP\LPC1788;..\..\uEZ\Source\Processor\NXP\LPC1788\Keil4\include;..\..\uEZ\Source\Platform\FDI\uEZGUI_1788_43WQS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\uEZGUI-1788.sct
  group Build
    ./: Config_Build.h main.c
  group Source
    ./Source/: Calibration.c Calibration.h Config_App.h Hello_World.c Hello_World.h NVSettings.c NVSettings.h Audio.c
  group uEZ/Source/Platform/uEZGUI-1788-43WQS
    ../../uEZ/Source/Platform/FDI/uEZGUI_1788_43WQS/: uEZGUI_1788_43WQS.c uEZPlatform.h
  group uEZ/Build/Generic/NXP/LPC1788/FreeRTOS/Keil4.x
    ../../uEZ/Build/Generic/NXP/LPC1788/FreeRTOS/Keil4.x/Debug/: uEZ_NXP_LPC1788_FreeRTOS_Keil4_Debug.lib
    ../../uEZ/Build/Generic/NXP/LPC1788/FreeRTOS/Keil4.x/Release/: uEZ_NXP_LPC1788_FreeRTOS_Keil4_Release.lib
target Release (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: Keil_Template +hex
  c flags: Optim=1 wLevel=1
  c define: COMPILER_TYPE=Keil4, GCC_ARMCM3, DEBUG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\uEZGUI-1788.sct
