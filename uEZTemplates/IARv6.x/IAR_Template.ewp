# IAR project IAR_Template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.IExtraOptions: --no_unaligned_access; --enum_is_int
  ICCARM.CCIncludePath2: .; Source; ../../uEZ/; ../../uEZ/Include; ../../uEZ/Source/Platform/FDI/uEZGUI_1788_43WQS; ../../uEZ/Source/Processor/NXP/LPC1788; ../../uEZ/Source/Processor/NXP/LPC1788/IAR/include; ../../uEZ/Source/RTOS/FreeRTOS/include; ../../uEZ/Source/RTOS/FreeRTOS/portable/IAR/ARM_CM3
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: .; Source; ../../uEZ/Include; ../../uEZ/Source/Platform/FDI/uEZGUI_1788_43WQS
  OBJCOPY.OOCOutputFile: IAR_Template.srec
  ILINK.IlinkOutputFile: IAR_Template.out
  ILINK.IlinkIcfFile: uEZGUI_1788.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  group (top)
    ./: Config_Build.h main.c
  group Source
    Source/: Audio.c Audio.h Calibration.c Calibration.h Config_App.h Hello_World.c Hello_World.h NVSettings.c NVSettings.h
  group uEZFiles/Platform
    ../../uEZ/Source/Platform/FDI/uEZGUI_1788_43WQS/: uEZGUI_1788_43WQS.c uEZPlatform.h
  group uEZFiles/uEZ Library
    ../../uEZ/Build/Generic/NXP/LPC1788/FreeRTOS/IAR6.x/Release/Exe/: uEZ_NXP_LPC1788_FreeRTOS_IAR6_Release.a
