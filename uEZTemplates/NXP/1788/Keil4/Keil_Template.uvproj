# Keil uVision project Keil_Template.uvproj, settings and files
target Debug (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Keil_Template +hex
  c flags: Optim=1 wLevel=1
  c define: COMPILER_TYPE=Keil4, GCC_ARMCM3, DEBUG
  c include: .;.\Source;..\..\..\..\uEZ;..\..\..\..\uEZ\Include;..\..\..\..\uEZ\Source\RTOS\FreeRTOS\include;..\..\..\..\uEZ\Source\Processor\NXP\LPC1788;..\..\..\..\uEZ\Source\Processor\NXP\LPC1788\Keil4\include;..\..\..\..\uEZ\Source\Platform\FDI\uEZGUI_1788_43WQS;..\..\..\..\..\..\..\..\Source\App\uEZDemoCommon;..\..\..\..\..\..\..\..\..\uEZ\Source\Platform\FDI\UEZGUI_1788_70WVT
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\uEZGUI-1788-70WVT.sct
  link misc: --verbose
  group Build
    ./: Config_Build.h main.c
  group Source
    ./Source/: Calibration.c Calibration.h Config_App.h Hello_World.c Hello_World.h NVSettings.c NVSettings.h Audio.c
  group uEZ/Build/Generic/NXP/LPC1788/FreeRTOS/Keil4.x
    ../../../../uEZ/Build/Generic/NXP/LPC1788/FreeRTOS/Keil4.x/Debug/: uEZ_NXP_LPC1788_FreeRTOS_Keil_Debug.lib
    ../../../../uEZ/Build/Generic/NXP/LPC1788/FreeRTOS/Keil4.x/Release/: uEZ_NXP_LPC1788_FreeRTOS_Keil_Release.lib
    ../../../../uEZ/Build/Generic/NXP/LPC1788/FreeRTOS/Keil4.x/Debug-Trace/: uEZ_NXP_LPC1788_FreeRTOS_Keil_Debug-Trace.lib
  group 70WVT
    ../../../../uEZ/Source/Platform/FDI/uEZGUI_1788_70WVT/: uEZGUI-1788-70WVT.c uEZPlatform.h
  group 70WVE
    ../../../../uEZ/Source/Platform/FDI/uEZGUI_1788_70WVE/: uEZGUI-1788-70WVE.c uEZPlatform.h
  group 43WQS
    ../../../../uEZ/Source/Platform/FDI/uEZGUI_1788_43WQS/: uEZGUI_1788_43WQS.c uEZPlatform.h
  group 43WQR
    ../../../../uEZ/Source/Platform/FDI/uEZGUI_1788_43WQR/: uEZGUI_1788_43WQR.c uEZPlatform.h
  group 56VI
    ../../../../uEZ/Source/Platform/FDI/uEZGUI_1788_56VI/: uEZGUI-1788-56VI.c uEZPlatform.h
target Release (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: Keil_Template +hex
  c flags: Optim=1 wLevel=1
  c define: COMPILER_TYPE=Keil4, GCC_ARMCM3, DEBUG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\uEZGUI-1788-70WVT.sct
  link misc: --verbose
target Debug-Trace (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: Keil_Template +hex
  c flags: Optim=1 wLevel=1
  c define: COMPILER_TYPE=Keil4, GCC_ARMCM3, DEBUG, FREERTOS_PLUS_TRACE
  c include: .;.\Source;..\..\..\..\uEZ;..\..\..\..\uEZ\Include;..\..\..\..\uEZ\Source\RTOS\FreeRTOS\include;..\..\..\..\uEZ\Source\RTOS\FreeRTOS-Plus\FreeRTOS-Plus-Trace\Include;..\..\..\..\uEZ\Source\Processor\NXP\LPC1788;..\..\..\..\uEZ\Source\Processor\NXP\LPC1788\Keil4\include;..\..\..\..\uEZ\Source\Platform\FDI\uEZGUI_1788_43WQS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\uEZGUI-1788-70WVT.sct
  link misc: --verbose
