# IAR project IAR_Template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.IExtraOptions: --no_unaligned_access; --enum_is_int
  ICCARM.CCIncludePath2: .; Source; ../../../../uEZ/; ../../../../uEZ/Include; ../../../../uEZ/Source/Platform/FDI/uEZGUI_1788_43WQS; ../../../../uEZ/Source/Processor/NXP/LPC1788; ../../../../uEZ/Source/Processor/NXP/LPC1788/IAR/include; ../../../../uEZ/Source/RTOS/FreeRTOS/include; ../../../../uEZ/Source/RTOS/FreeRTOS/portable/IAR/ARM_CM3
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: .; Source; ../../uEZ/Include; ../../uEZ/Source/Platform/FDI/uEZGUI_1788_43WQS
  OBJCOPY.OOCOutputFile: IAR_Template.hex
  ILINK.IlinkOutputFile: IAR_Template.out
  ILINK.IlinkIcfFile: uEZGUI_1788.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: .; Source; ../../uEZ/; ../../uEZ/Include; ../../uEZ/Source/Platform/FDI/uEZGUI_1788_43WQS; ../../uEZ/Source/Processor/NXP/LPC1788; ../../uEZ/Source/Processor/NXP/LPC1788/IAR/include; ../../uEZ/Source/RTOS/FreeRTOS/include; ../../uEZ/Source/RTOS/FreeRTOS/portable/IAR/ARM_CM3
configuration Debug-Trace (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: FREERTOS_PLUS_TRACE
  ICCARM.CCIncludePath2: .; Source; ../../../../uEZ/; ../../../../uEZ/Include; ../../../../uEZ/Source/Platform/FDI/uEZGUI_1788_43WQR; ../../../../uEZ/Source/Processor/NXP/LPC1788; ../../../../uEZ/Source/Processor/NXP/LPC1788/IAR/include; ../../../../uEZ/Source/RTOS/FreeRTOS/include; ../../../../uEZ/Source/RTOS/FreeRTOS/portable/IAR/ARM_CM3; ../../../../uEZ/Source/RTOS/FreeRTOS-Plus/FreeRTOS-Plus-Trace/include
  group (top)
    ./: Config_Build.h main.c
  group Source
    Source/: Audio.c Audio.h Calibration.c Calibration.h Config_App.h Hello_World.c Hello_World.h NVSettings.c NVSettings.h
  group uEZFiles/Source\Platform\FDI\uEZGUI-1788-/43WQR
    ../../../../uEZ/Source/Platform/FDI/uEZGUI_1788_43WQR/: uEZGUI_1788_43WQR.c uEZPlatform.h
  group uEZFiles/Source\Platform\FDI\uEZGUI-1788-/43WQS
    ../../../../uEZ/Source/Platform/FDI/uEZGUI_1788_43WQS/: uEZGUI_1788_43WQS.c uEZPlatform.h
  group uEZFiles/Source\Platform\FDI\uEZGUI-1788-/56VI
    ../../../../uEZ/Source/Platform/FDI/uEZGUI_1788_56VI/: uEZGUI-1788-56VI.c uEZPlatform.h
  group uEZFiles/Source\Platform\FDI\uEZGUI-1788-/70WVE
    ../../../../uEZ/Source/Platform/FDI/uEZGUI_1788_70WVE/: uEZGUI-1788-70WVE.c uEZPlatform.h
  group uEZFiles/Source\Platform\FDI\uEZGUI-1788-/70WVM
    ../../../../uEZ/Source/Platform/FDI/uEZGUI_1788_70WVM/: uEZGUI-1788-70WVM.c uEZPlatform.h
  group uEZFiles/Source\Platform\FDI\uEZGUI-1788-/70WVT
    ../../../../uEZ/Source/Platform/FDI/uEZGUI_1788_70WVT/: uEZGUI-1788-70WVT.c uEZPlatform.h
  group uEZFiles/uEZ Library
    ../../../../uEZ/Build/Generic/NXP/LPC1788/FreeRTOS/IAR6.x/Debug-Trace/Exe/: uEZ_NXP_LPC1788_FreeRTOS_IAR6_Debug-Trace.a
    ../../../../uEZ/Build/Generic/NXP/LPC1788/FreeRTOS/IAR6.x/Debug/Exe/: uEZ_NXP_LPC1788_FreeRTOS_IAR6_Debug.a
    ../../../../uEZ/Build/Generic/NXP/LPC1788/FreeRTOS/IAR6.x/Release/Exe/: uEZ_NXP_LPC1788_FreeRTOS_IAR6_Release.a
