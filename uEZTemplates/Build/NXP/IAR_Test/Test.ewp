# IAR project Test.ewp, settings and files
configuration Debug (ARM, debug)
  General.CoreVariant: 39
  General.FPU2: 4
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788; LPC4088 NXP LPC4088; LPC4357_M4 NXP LPC4357_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M3; CORE_M4; __FPU_PRESENT=1; CORE_M4; __FPU_PRESENT=1; LWIP_2_0_x; DEBUG
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: .; ../../../Source/AppTest; ../../../../uEZ; ../../../../uEZ/Include; ../../../../uEZ/Source/RTOS/$[sym rtos]/include; ../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx; ../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx/Common/include; ../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx/Common/include/CMSIS; ../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx/IAR; ../../../../uEZ/Source/RTOS/FreeRTOS/portable/IAR/ARM_CM3; ../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx; ../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx/Common/include; ../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx/Common/include/CMSIS; ../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx/IAR; ../../../../uEZ/Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../uEZ/Source/Processor/NXP/LPC43xx; ../../../../uEZ/Source/Processor/NXP/LPC43xx/Common/include; ../../../../uEZ/Source/Processor/NXP/LPC43xx/Common/include/CMSIS; ../../../../uEZ/Source/Processor/NXP/LPC43xx/IAR; ../../../../uEZ/Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../uEZ/Source/Library/LPCOpen; ../../../../uEZ/Source/Library/LPCOpen/chip_18xx_43xx; ../../../../uEZ/Source/RTOS/$[sym rtos]/portable/IAR/$[ifdef LPC1788]ARM_CM3$[endif]$[ifdef LPC4088]ARM_CM4F$[endif]$[ifdef LPC4357]ARM_CM4F$[endif]; ../../../../uEZ/Source/Library/Encryption/mbedtls/include; ../../../../uEZ/Source/Library/Encryption/mbedtls; ../../../../uEZ/Source/Library/Encryption/mbedtls/include; ../../../../uEZ/Source/Library/Encryption/mbedtls; ../../../../uEZ/Source/Library/lwip_2.0.x/src/include; ../../../../uEZ/Source/Library/lwip_2.0.x/src; ../../../../uEZ/Source/Library/lwip_2.0.x/Include; ../../../../uEZ/Source/Library/lwip_2.0.x/src/include/ipv4; ../../../../uEZ/Source/Library/lwip_2.0.x/system; ../../../../uEZ/Source/Library/lwip_2.0.x/system/arch; ../../../../uEZ/Source/Platform/FDI/$[sym platform]; ../../../../uEZ/Source/Library/GUI/SEGGER/emWin; ../../../../uEZ/Source/Platform/emWin/Inc; ../../../../uEZ/Source/Platform/emWin/Config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: .; ../../../Source/AppTest; ../../../../uEZ; ../../../../uEZ/Include; ../../../../uEZ/Source/RTOS/$[sym rtos]/include; ../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx; ../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx/Common/include; ../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx/Common/include/CMSIS; ../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx/IAR; ../../../../uEZ/Source/RTOS/FreeRTOS/portable/IAR/ARM_CM3; ../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx; ../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx/Common/include; ../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx/Common/include/CMSIS; ../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx/IAR; ../../../../uEZ/Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../uEZ/Source/Processor/NXP/LPC43xx; ../../../../uEZ/Source/Processor/NXP/LPC43xx/Common/include; ../../../../uEZ/Source/Processor/NXP/LPC43xx/Common/include/CMSIS; ../../../../uEZ/Source/Processor/NXP/LPC43xx/IAR; ../../../../uEZ/Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../uEZ/Source/Library/LPCOpen; ../../../../uEZ/Source/Library/LPCOpen/chip_18xx_43xx; ../../../../uEZ/Source/RTOS/$[sym rtos]/portable/IAR/$[ifdef LPC1788]ARM_CM3$[endif]$[ifdef LPC4088]ARM_CM4F$[endif]$[ifdef LPC4357]ARM_CM4F$[endif]; ../../../../uEZ/Source/Library/Encryption/mbedtls/include; ../../../../uEZ/Source/Library/Encryption/mbedtls; ../../../../uEZ/Source/Library/lwip_2.0.x/src/include; ../../../../uEZ/Source/Library/lwip_2.0.x/src; ../../../../uEZ/Source/Library/lwip_2.0.x/Include; ../../../../uEZ/Source/Library/lwip_2.0.x/src/include/ipv4; ../../../../uEZ/Source/Library/lwip_2.0.x/system; ../../../../uEZ/Source/Library/lwip_2.0.x/system/arch; ../../../../uEZ/Source/Platform/FDI/$[sym platform]; ../../../../uEZ/Source/Library/GUI/SEGGER/emWin; ../../../../uEZ/Source/Platform/emWin/Inc; ../../../../uEZ/Source/Platform/emWin/Config
  OBJCOPY.OOCOutputFile: $[sym project_name].hex
  ILINK.IlinkOutputFile: $[sym project_name].out
  ILINK.IlinkIcfFile: Test.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 0; 4; 4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M3; CORE_M4; __FPU_PRESENT=1; CORE_M4; __FPU_PRESENT=1; LWIP_2_0_x; NDEBUG
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  group (top)
    ./: Config_Build.h Test.icf
    ../../../../uEZ/Build/Generic/$[sym manufacturer]/$[sym processor]/$[sym rtos]/IAR/Debug/Exe/: uEZ_$[sym manufacturer]_$[sym processor]_$[sym rtos]_IAR_Debug.a
    ../../../../uEZ/Build/Generic/$[sym manufacturer]/$[sym processor]/$[sym rtos]/IAR/Release/Exe/: uEZ_$[sym manufacturer]_$[sym processor]_$[sym rtos]_IAR_Release.a
  group Include
    ../../../../uEZ/Include/: build_time.h Config.h fcntl.h Global.h lwipopts.h lwippools.h netdb.h SEGGER_RTT_SYSVIEW_Config.h signal.h uEZ.h uEZAccelerometer.h uEZADC.h uEZAudioAmp.h uEZAudioMixer.h uEZBSP.h uEZButton.h uEZCAN.h uEZCharDisplay.h uEZCRC.h uEZDAC.h uEZDevice.h uEZDeviceTable.h uEZEEPROM.h uEZEINT.h uEZErrors.h uEZFile.h uEZFlash.h uEZGPIO.h uEZHID.h uEZI2C.h uEZINI.h uEZInline.h uEZKeypad.h uEZLCD.h uEZLEDBank.h uEZMemory.h uEZNetwork.h uEZPacked.h uEZPlatformAPI.h uEZProcessor.h uEZPWM.h uEZRandom.h uEZResourceCache.h uEZRTOS.h uEZSPI.h uEZStream.h uEZTemperature.h uEZTickCounter.h uEZTimeDate.h uEZTimer.h uEZToneGenerator.h uEZTS.h uEZTypes.h uEZWatchdog.h uEZWAVFile.h unistd.h
  group Include/Device
    ../../../../uEZ/Include/Device/: Accelerometer.h ADCBank.h Backlight.h ButtonBank.h CharDisplay.h EEPROM.h ExternalInterrupt.h FileSystem.h Flash.h I2CBus.h Keypad.h LCD.h LEDBank.h MassStorage.h PWM.h RTC.h SPIBus.h Stream.h Temperature.h ToneGenerator.h Touchscreen.h USBDevice.h USBHost.h
  group Include/Device/LCD
    ../../../../uEZ/Include/Device/LCD/: Config_LCD.h
  group Include/HAL
    ../../../../uEZ/Include/HAL/: ADCBank.h EMAC.h GPIO.h HAL.h I2CBus.h Interrupt.h LCDController.h PWM.h RTC.h Serial.h SPI.h Timer.h USBDeviceController.h USBHost.h Watchdog.h
  group Include/netinet
    ../../../../uEZ/Include/netinet/: in.h
  group Include/sys
    ../../../../uEZ/Include/sys/: mman.h socket.h stat.h time.h types.h
  group Include/Types
    ../../../../uEZ/Include/Types/: Accelerometer.h ADC.h EEPROM.h EMAC.h File.h Flash.h I2C.h InputEvent.h LCD.h Serial.h SPI.h TimeDate.h USBDevice.h USBHost.h
  group Source/AppTest
    ../../../Source/AppTest/: App_RTOS.c Audio.c Audio.h Calibration.c Calibration.h Config_App.h main.c NetworkStartup.c NetworkStartup.h NVSettings.c NVSettings.h TSNoiseDetect.c TSNoiseDetect.h Storage_Callbacks.c Storage_Callbacks.h
  group Source/AppTest/emWin
    ../../../Source/AppTest/emWin/: Create_Window_Functions.h HomeScreen.c Keyboard.c Keyboard.h Keypad.c Keypad.h LookAndFeel.c LookAndFeel.h WindowManager.c WindowManager.h StorageWindow.c SlideShow_EFlash.c
  group Source/AppTest/emWin/Fonts
    ../../../Source/AppTest/emWin/Fonts/: Fonts.h
  group Source/AppTest/emWin/Graphics
    ../../../Source/AppTest/emWin/Graphics/: Graphics.h logo.c 1.c 2.c 3.c 4.c 5.c
  group Source/Library/GUI/SEGGER/emWin
    ../../../../uEZ/Source/Library/GUI/SEGGER/emWin/: BUTTON.h BUTTON_Private.h CALENDAR.h CHECKBOX.h CHECKBOX_Private.h CHOOSECOLOR.h CHOOSEFILE.h DIALOG.h DIALOG_Intern.h DROPDOWN.h DROPDOWN_Private.h EDIT.h EDIT_Private.h FRAMEWIN.h FRAMEWIN_Private.h GRAPH.h GRAPH_Private.h GUI.h GUI__BiDi2_Brackets_800.h GUI__BiDi2_Types_800.h GUI_ARRAY.h GUI_ARRAY_Private.h GUI_BMP_Private.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_GCache_Private.h GUI_GIF_Private.h GUI_HOOK.h GUI_JPEG_Private.h GUI_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_SPRITE_Private.h GUI_Type.h GUI_Version.h GUI_VNC.h GUIDRV_BitPlains.h GUIDRV_DCache.h GUIDRV_DCache_Private.h GUIDRV_Dist.h GUIDRV_FlexColor.h GUIDRV_FlexColor_Private.h GUIDRV_IST3088.h GUIDRV_IST3088_Private.h GUIDRV_Lin.h GUIDRV_Lin_Opt_16.h GUIDRV_Lin_Opt_24.h GUIDRV_Lin_Opt_32.h GUIDRV_Lin_Opt_8.h GUIDRV_Lin_Private.h GUIDRV_NoOpt_1_8.h GUIDRV_S1D13748.h GUIDRV_S1D13748_Private.h GUIDRV_S1D13781.h GUIDRV_S1D13781_Private.h GUIDRV_S1D15G00.h GUIDRV_SLin.h GUIDRV_SLin_Private.h GUIDRV_SPage.h GUIDRV_SPage_Private.h GUIDRV_SSD1926.h GUIDRV_SSD1926_Private.h GUIDRV_Template.h GUIDRV_TemplateI.h GUIDRV_TemplateI_Private.h GUIDRV_UC1698G4.h GUITDRV_ADS7846.h HEADER.h HEADER_Private.h ICONVIEW.h ICONVIEW_Private.h IMAGE.h IMAGE_Private.h IP_FS.h KNOB.h KNOB_Private.h LCD.h LCD_ConfDefaults.h LCD_Private.h LCD_Protected.h LCD_SIM.h LISTBOX.h LISTBOX_Private.h LISTVIEW.h LISTVIEW_Private.h LISTWHEEL.h LISTWHEEL_Private.h MENU.h MENU_Private.h MESSAGEBOX.h MULTIEDIT.h MULTIPAGE.h MULTIPAGE_Private.h PROGBAR.h PROGBAR_Private.h RADIO.h RADIO_Private.h SCROLLBAR.h SCROLLBAR_Private.h SEGGER.h SLIDER.h SLIDER_Private.h SPINBOX.h SPINBOX_Private.h SWIPELIST.h SWIPELIST_Private.h TEXT.h TEXT_Private.h TREEVIEW.h TREEVIEW_Private.h WIDGET.h WINDOW_Private.h WM.h WM_GUI.h WM_Intern.h
  group Source/Library/GUI/SEGGER/emWin/Library/$[sym manufacturer]
    ../../../../uEZ/Source/Library/GUI/SEGGER/emWin/Libraries/NXP/IAR/: emWin_IAR_M3.a
  group Source/Platform/FDI/$[sym platform]
    ../../../../uEZ/Source/Platform/FDI/$[sym platform]/: $[sym platform].c uEZPlatform.h uEZPlatformTest.c
