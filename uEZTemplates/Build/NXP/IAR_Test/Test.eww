<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Test.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>Test</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>Test</project>
        <configuration>Debug-Trace</configuration>
      </member>
      <member>
        <project>Test</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


