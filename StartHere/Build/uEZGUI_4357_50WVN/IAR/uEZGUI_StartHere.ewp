# IAR project uEZGUI_StartHere.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: IAR_ARM_CM4F; CORE_M4
  ICCARM.IExtraOptions: --no_unaligned_access; --enum_is_int
  ICCARM.CCIncludePath2: .; ../../../Source/App/; ../../../../uEZ; ../../../../uEZ/Include; ../../../../uEZ/Source/Platform/FDI/uEZGUI_4357_50WVN; ../../../../uEZ/Source/Processor/NXP/LPC43xx; ../../../../uEZ/Source/Processor/NXP/LPC43xx/IAR/include; ../../../../uEZ/Source/Processor/NXP/LPC43xx/IAR/include/CMSIS; ../../../../uEZ/Source/RTOS/freertos/include; ../../../../uEZ/Source/RTOS/freertos/portable/IAR/ARM_CM3; ../../../../uEZ/Source/Library/GUI/SEGGER/emWin; ../../../../uEZ/Source/Platform/emWin/Inc; ../../../../uEZ/Source/Platform/emWin/Config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uEZGUI_StartHere.hex
  ILINK.IlinkOutputFile: uEZGUI_StartHere.out
  ILINK.IlinkIcfFile: lpc4357_m4_SDRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; IAR_ARM_CM4F; CORE_M4
  ICCARM.CCOptLevel: 3
  group (top)
    ../../../../uEZ/Build/Generic/NXP/LPC4357/FreeRTOS/IAR/Debug/Exe/: uEZ_NXP_LPC4357_FreeRTOS_IAR_Debug.a
    ../../../../uEZ/Build/Generic/NXP/LPC4357/FreeRTOS/IAR/Release/Exe/: uEZ_NXP_LPC4357_FreeRTOS_IAR_Release.a
  group Build
    ./: Config_Build.h lpc4357_m4_SDRAM.icf
  group Source/App
    ../../../Source/App/: Calibration.c Calibration.h Config_App.h main.c NVSettings.c NVSettings.h
  group Source/App/emWin
    ../../../Source/App/emWin/: Create_Window_Functions.h HomeScreen.c LookAndFeel.c LookAndFeel.h WindowManager.c WindowManager.h
  group Source/App/emWin/Fonts
    ../../../Source/App/emWin/Fonts/: Fonts.h
  group Source/App/emWin/Graphics
    ../../../Source/App/emWin/Graphics/: Graphics.h
  group Source/Library/emWin
    ../../../../uEZ/Source/Library/GUI/SEGGER/emWin/Libraries/NXP/IAR/: emWin_524h_IAR_M4.a emWin_530_IAR_M4F.a
  group Source/Platform/FDI/uEZGUI_4357_50WVN
    ../../../../uEZ/Source/Platform/FDI/uEZGUI_4357_50WVN/: uEZGUI_4357_50WVN.c uEZPlatform.h
