/*-------------------------------------------------------------------------*
 * File:  LPC2478_Bus.c
 *-------------------------------------------------------------------------*
 * Description:
 *     
 *-------------------------------------------------------------------------*/

/*--------------------------------------------------------------------------
 * uEZ(R) - Copyright (C) 2007-2012 Future Designs, Inc.
 *--------------------------------------------------------------------------
 * This file is part of the uEZ(R) distribution.  See the included
 * uEZLicense.txt or visit http://www.teamfdi.com/uez for details.
 *
 *    *===============================================================*
 *    |  Future Designs, Inc. can port uEZ(tm) to your own hardware!  |
 *    |             We can get you up and running fast!               |
 *    |      See http://www.teamfdi.com/uez for more details.         |
 *    *===============================================================*
 *
 *-------------------------------------------------------------------------*/

/*-------------------------------------------------------------------------*
 * Includes:
 *-------------------------------------------------------------------------*/
#include <uEZ.h>
#include <uEZProcessor.h>

/*-------------------------------------------------------------------------*
 * Constants:
 *-------------------------------------------------------------------------*/

/*-------------------------------------------------------------------------*
 * Types:
 *-------------------------------------------------------------------------*/

/*-------------------------------------------------------------------------*
 * Prototypes:
 *-------------------------------------------------------------------------*/
void LPC2478_ExternalAddressBus_ConfigureIOPins(TUInt8 aBitSize)
{
    int i, j;

    if (aBitSize > 24)
        aBitSize = 24;

    // Change PINSEL for Address pins 0-23
    for (i=0,j=0; (i<16) && (i < aBitSize); i++, j+=2) {
        PINSEL8 &= ~(3<<j);
        PINSEL8 |= (1<<j);
    }
    for (i=16, j=0; i<aBitSize; i++, j+=2) {
        PINSEL9 &= ~(3<<j);
        PINSEL9 |= (1<<j);
    }
}

void LPC2478_ExternalDataBus_ConfigureIOPins(TUInt8 aBitSize)
{
    int i, j;
    if (aBitSize > 32)
        aBitSize = 32;

    // Change PINSEL for Data pins 0-31
    for (i=0,j=0; (i<16) && (i < aBitSize); i++, j+=2) {
        PINSEL6 &= ~(3<<j);
        PINSEL6 |= (1<<j);
    }
    for (i=16, j=0; i<aBitSize; i++, j+=2) {
        PINSEL7 &= ~(3<<j);
        PINSEL7 |= (1<<j);
    }
}

/*-------------------------------------------------------------------------*
 * End of File:  LPC2478_Bus.c
 *-------------------------------------------------------------------------*/
