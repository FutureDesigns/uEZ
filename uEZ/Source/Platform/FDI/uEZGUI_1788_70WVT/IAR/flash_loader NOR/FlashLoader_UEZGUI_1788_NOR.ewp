# IAR project FlashLoader_UEZGUI_1788_NOR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG
  ICCARM.CCIncludePath2: ; src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FlashLoader_UEZGUI_1788_NOR.hex
  ILINK.IlinkOutputFile: FlashLoader_UEZGUI_1788_NOR.out
  ILINK.IlinkIcfFile: config\uEZGUI_1788_NOR.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: FlashLoader_UEZGUI_1788_NOR.srec
  group (top)
    src/: Flash_S29GL064N90.c Flash_S29GL064N90.h FlashLoader_UEZGUI_1788_NOR.c FlashLoader_UEZGUI_1788_NOR.h LPC1788_BSP.c LPC1788_BSP.h uEZ.h uEZErrors.h uEZFlash.h uEZTypes.h
    ./: uEZGUI_1788_70WVE_NOR.board uEZGUI_1788_70WVE_NOR.flash
  group config
    config/: LPC177x_8x.mac uEZGUI_1788_NOR.icf
  group framework
    src/framework/: flash_config.h flash_loader.c flash_loader.h flash_loader_asm.s flash_loader_extra.h
