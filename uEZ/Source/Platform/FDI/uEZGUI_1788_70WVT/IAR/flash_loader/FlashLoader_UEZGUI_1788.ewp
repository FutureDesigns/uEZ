# IAR project FlashLoader_UEZGUI_1788.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: 
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FlashLoader_UEZGUI_1788.hex
  ILINK.IlinkOutputFile: FlashLoader_UEZGUI_1788.out
  ILINK.IlinkIcfFile: config\uEZGUI_1788.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: FlashLoader_UEZGUI_1788.srec
  group (top)
    src/: FlashLoader_UEZGUI_1788.c FlashLoader_UEZGUI_1788.h
    ./: uEZGUI_1788_70WVE.board uEZGUI_1788_70WVE.flash
  group config
    config/: LPC177x_8x.mac uEZGUI_1788.icf
  group framework
    src/framework/: flash_config.h flash_loader.c flash_loader.h flash_loader_asm.s flash_loader_extra.h
