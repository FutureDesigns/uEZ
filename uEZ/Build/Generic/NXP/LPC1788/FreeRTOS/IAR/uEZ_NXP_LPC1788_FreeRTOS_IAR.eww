<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\uEZ_NXP_LPC1788_FreeRTOS_IAR.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>uEZ_NXP_LPC1788_FreeRTOS_IAR</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>uEZ_NXP_LPC1788_FreeRTOS_IAR</project>
        <configuration>Debug-Trace</configuration>
      </member>
      <member>
        <project>uEZ_NXP_LPC1788_FreeRTOS_IAR</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


