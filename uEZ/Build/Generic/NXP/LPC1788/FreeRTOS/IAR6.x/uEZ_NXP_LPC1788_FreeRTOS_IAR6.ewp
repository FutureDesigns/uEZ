# IAR project uEZ_NXP_LPC1788_FreeRTOS_IAR6.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: LWIP_PROVIDE_ERRNO; UEZ_LIBRARY
  ICCARM.CCDiagSuppress: Pa082,Pa039
  ICCARM.IExtraOptions: --no_unaligned_access; --enum_is_int
  ICCARM.CCIncludePath2: .; ../../../../../../.; ../../../../../../Include; ../../../../../../Source/App/Demos/uEZGUI-1788-43WQS; ../../../../../../Source/Processor/NXP/LPC17xx_40xx; ../../../../../../Source/Processor/NXP/LPC17xx_40xx/IAR/include; ../../../../../../Source/RTOS/FreeRTOS/include; ../../../../../../Source/RTOS/FreeRTOS/portable/IAR/ARM_CM3; ../../../../../../Source/Library/lwIP/src/include; ../../../../../../Source/Library/lwIP/src; ../../../../../../Source/Library/lwIP/Include; ../../../../../../Source/Library/lwIP/src/include/ipv4; ../../../../../../Source/Platform/emWin/Inc; ../../../../../../Source/Platform/emWin/Config; ../../../../../../Source/Library/GUI/SEGGER/emWin
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: .; ../../../../../../.; ../../../../../../Include; ../../../../../../Source/App/Demos/uEZGUI-1788-43WQS; ../../../../../../Source/Processor/NXP/LPC17xx_40xx; ../../../../../../Source/Processor/NXP/LPC17xx_40xx/IAR/include; ../../../../../../Source/RTOS/FreeRTOS/include; ../../../../../../Source/RTOS/FreeRTOS/portable/IAR/ARM_CM3; ../../../../../../Source/Library/lwIP/src/include; ../../../../../../Source/Library/lwIP/src; ../../../../../../Source/Library/lwIP/Include; ../../../../../../Source/Library/lwIP/src/include/ipv4
  OBJCOPY.OOCOutputFile: UEZGUIDemo.hex
  ILINK.IlinkOutputFile: UEZGUIDemo.out
  ILINK.IlinkIcfFile: uEZGUI_1788.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1778 NXP LPC1778
  ICCARM.CCDefines: NDEBUG; UEZ_LIBRARY
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: uEZGUI-1788-43WQS.hex
configuration Debug-Trace (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: LWIP_PROVIDE_ERRNO; UEZ_LIBRARY; FREERTOS_PLUS_TRACE
  ICCARM.CCIncludePath2: .; ../../../../../../.; ../../../../../../Include; ../../../../../../Source/App/Demos/uEZGUI-1788-43WQS; ../../../../../../Source/Processor/NXP/LPC17xx_40xx; ../../../../../../Source/Processor/NXP/LPC17xx_40xx/IAR/include; ../../../../../../Source/RTOS/FreeRTOS/include; ../../../../../../Source/RTOS/FreeRTOS/portable/IAR/ARM_CM3; ../../../../../../Source/RTOS/FreeRTOS-Plus/FreeRTOS-Plus-Trace/include; ../../../../../../Source/Library/lwIP/src/include; ../../../../../../Source/Library/lwIP/src; ../../../../../../Source/Library/lwIP/Include; ../../../../../../Source/Library/lwIP/src/include/ipv4; ../../../../../../Source/Platform/emWin/Inc; ../../../../../../Source/Platform/emWin/Config; ../../../../../../Source/Library/GUI/SEGGER/emWin
  group (top)
    ./: Config_Build.h
  group Include
    ../../../../../../Include/: Config.h fcntl.h netdb.h signal.h uEZ.h uEZAccelerometer.h uEZADC.h uEZAudioAmp.h uEZBSP.h uEZButton.h uEZCharDisplay.h uEZDAC.h uEZDevice.h uEZDeviceTable.h uEZEINT.h uEZErrors.h uEZFile.h uEZFlash.h uEZGPIO.h uEZHID.h uEZI2C.h uEZINI.h uEZInline.h uEZKeypad.h uEZLCD.h uEZLEDBank.h uEZMemory.h uEZNetwork.h uEZPacked.h UEZPlatformAPI.h uEZProcessor.h uEZPWM.h uEZRandom.h uEZResourceCache.h uEZRTOS.h uEZStream.h uEZTemperature.h uEZTickCounter.h uEZTimeDate.h uEZTimer.h uEZToneGenerator.h uEZTS.h uEZTypes.h uEZWatchdog.h UEZWAVFile.h unistd.h
  group Include/Device
    ../../../../../../Include/Device/: Accelerometer.h ADCBank.h AudioAmp.h AudioCodec.h Backlight.h ButtonBank.h CharDisplay.h DAC.h EEPROM.h ExternalInterrupt.h FileSystem.h Flash.h GPDMA.h HID.h I2CBus.h I2S.h Keypad.h LCD.h LEDBank.h LightSensor.h MassStorage.h Network.h PWM.h ResourceCache.h RTC.h SPIBus.h Stream.h Temperature.h Timer.h ToneGenerator.h Touchscreen.h USBDevice.h USBHost.h Watchdog.h
  group Include/Device/LCD
    ../../../../../../Include/Device/LCD/: Config_LCD.h
  group Include/HAL
    ../../../../../../Include/HAL/: ADCBank.h BatteryRAM.h CRC.h DAC.h EEPROM.h EMAC.h ExternalInterrupt.h GPDMA.h GPIO.h HAL.h I2CBus.h I2SBus.h Interrupt.h LCDController.h PWM.h RTC.h Serial.h SPI.h Timer.h USBDeviceController.h USBHost.h Watchdog.h
  group Include/netinet
    ../../../../../../Include/netinet/: in.h
  group Include/sys
    ../../../../../../Include/sys/: mman.h socket.h stat.h time.h types.h
  group Include/Types
    ../../../../../../Include/Types/: Accelerometer.h ADC.h CRC.h EEPROM.h EINT.h EMAC.h File.h Flash.h GPDMA.h GPIO.h I2C.h I2S.h InputEvent.h LCD.h Network.h SDRAM.h Serial.h SPI.h TimeDate.h Timer.h USBDevice.h USBHost.h WAVFile.h
  group Source/Devices/Accelerometer/Analog Devices/ADXL345
    ../../../../../../Source/Devices/Accelerometer/Analog Devices/ADXL345/: Accelerometer_ADXL345.c Accelerometer_ADXL345.h
  group Source/Devices/Accelerometer/Bosch/BMA150
    ../../../../../../Source/Devices/Accelerometer/Bosch/BMA150/: Bosch_BMA150_I2C.h Bosch_BMA150_I2C_driver.c
  group Source/Devices/Accelerometer/Freescale/MMA7455
    ../../../../../../Source/Devices/Accelerometer/Freescale/MMA7455/: Freescale_MMA7455.h Freescale_MMA7455_driver.c
  group Source/Devices/Accelerometer/ST/LIS3LV02DQ
    ../../../../../../Source/Devices/Accelerometer/ST/LIS3LV02DQ/: ST_LIS3LV02DQ_I2C.h ST_LIS3LV02DQ_I2C_driver.c
  group Source/Devices/ADC/Generic
    ../../../../../../Source/Devices/ADC/Generic/: Generic_adc.c
  group Source/Devices/Audio Codec/Wolfson/WM8731
    ../../../../../../Source/Devices/Audio Codec/Wolfson/WM8731/: AudioCodec_WM8731.c AudioCodec_WM8731.h
  group Source/Devices/AudioAmp/NXP/TDA8551_T
    ../../../../../../Source/Devices/AudioAmp/NXP/TDA8551_T/: AudioAmp_8551T.c
  group Source/Devices/AudioAmp/TI/LM48100
    ../../../../../../Source/Devices/AudioAmp/TI/LM48100/: AudioAmp_LM48100.c AudioAmp_LM48100.h
  group Source/Devices/AudioAmp/Wolfson/WM8731
    ../../../../../../Source/Devices/AudioAmp/Wolfson/WM8731/: AudioAmp_WM8731.c AudioAmp_WM8731.h
  group Source/Devices/Backlight/Generic/BacklightPWMControlled
    ../../../../../../Source/Devices/Backlight/Generic/BacklightPWMControlled/: BacklightPWMControlled.c
  group Source/Devices/Button/NXP/PCA9551
    ../../../../../../Source/Devices/Button/NXP/PCA9551/: Button_NXP_PCA9551_driver.c
  group Source/Devices/CRC/Generic
    ../../../../../../Source/Devices/CRC/Generic/: CRC_Generic.c
  group Source/Devices/DAC/Generic
    ../../../../../../Source/Devices/DAC/Generic/: DAC_Generic.c
  group Source/Devices/EEPROM/Generic/I2C
    ../../../../../../Source/Devices/EEPROM/Generic/I2C/: EEPROM16_Generic_I2C.h EEPROM16_Generic_I2C_driver.c EEPROM_Generic_I2C.h EEPROM_Generic_I2C_driver.c
  group Source/Devices/EEPROM/NXP/LPC17xx_40xx
    ../../../../../../Source/Devices/EEPROM/NXP/LPC17xx_40xx/: EEPROM_NXP_LPC17xx_40xx.c EEPROM_NXP_LPC17xx_40xx.h
  group Source/Devices/ExternalInterrupt/Generic
    ../../../../../../Source/Devices/ExternalInterrupt/Generic/: ExternalInterrupt_Generic.c ExternalInterrupt_Generic.h
  group Source/Devices/Flash/NXP/LPC17xx_40xx
    ../../../../../../Source/Devices/Flash/NXP/LPC17xx_40xx/: LPC17xx_40xx_IAP.c LPC17xx_40xx_IAP.h
  group Source/Devices/Flash/Spansion/S29GL
    ../../../../../../Source/Devices/Flash/Spansion/S29GL/: Flash_S29GL064N90_16bit_driver.c
  group Source/Devices/GPDMA/Generic
    ../../../../../../Source/Devices/GPDMA/Generic/: Generic_GPDMA.c
  group Source/Devices/GPIO/I2C/PCF8574T
    ../../../../../../Source/Devices/GPIO/I2C/PCF8574T/: GPIO_PCF8574T.c GPIO_PCF8574T.h
  group Source/Devices/HID/Generic
    ../../../../../../Source/Devices/HID/Generic/: HID_Generic.c
  group Source/Devices/I2C/Generic
    ../../../../../../Source/Devices/I2C/Generic/: Generic_i2c.c
  group Source/Devices/I2C/Mux/PCA9546
    ../../../../../../Source/Devices/I2C/Mux/PCA9546/: I2C_Mux_PCA9546.c I2C_Mux_PCA9546.h
  group Source/Devices/I2S/Generic
    ../../../../../../Source/Devices/I2S/Generic/: Generic_i2s.c Generic_I2S.h
  group Source/Devices/Keypad/GPIO
    ../../../../../../Source/Devices/Keypad/GPIO/: Keypad_Generic_GPIO.c Keypad_Generic_GPIO.h
  group Source/Devices/Keypad/NXP/I2C_Keypad
    ../../../../../../Source/Devices/Keypad/NXP/I2C_Keypad/: Keypad_NXP_I2C_PCA9555.h Keypad_NXP_I2C_PCA9555_driver.c
  group Source/Devices/LCD/DigitalImage/FG050720DSSWDG01
    ../../../../../../Source/Devices/LCD/DigitalImage/FG050720DSSWDG01/: LCD_DigitalImage_FG050720DSSWDG01.c LCD_DigitalImage_FG050720DSSWDG01.h
  group Source/Devices/LCD/Hitachi/TX11D06VM2APA
    ../../../../../../Source/Devices/LCD/Hitachi/TX11D06VM2APA/: Hitachi_TX11D06VM2APA.c Hitachi_TX11D06VM2APA.h
  group Source/Devices/LCD/Inteltronic/LMIX0560NTN53V1
    ../../../../../../Source/Devices/LCD/Inteltronic/LMIX0560NTN53V1/: Inteltronic_LMIX0560NTN53V1.c Inteltronic_LMIX0560NTN53V1.h
  group Source/Devices/LCD/Inteltronic/LMTDA043ZHN3
    ../../../../../../Source/Devices/LCD/Inteltronic/LMTDA043ZHN3/: LMTDA043ZHN3.c LMTDA043ZHN3.h
  group Source/Devices/LCD/Microtips/UMSH-8596MD-20T
    ../../../../../../Source/Devices/LCD/MicroTips/UMSH-8596MD-20T/: Microtips_UMSH_8596MD_20T.c Microtips_UMSH_8596MD_20T.h
  group Source/Devices/LCD/NEC/NL6448BC18-03F
    ../../../../../../Source/Devices/LCD/NEC/NL6448BC18-03F/: NEC-NL6448Bc18.c NEC-NL6448BC18.h
  group Source/Devices/LCD/Newhaven/NHD43480272MF
    ../../../../../../Source/Devices/LCD/NewHaven/NHD43480272MF/: NewHaven_NHD43480272MF.c NewHaven_NHD43480272MF.h
  group Source/Devices/LCD/OKAYA/RH320240T
    ../../../../../../Source/Devices/LCD/OKAYA/RH320240T/: Okaya_rh320240t.c Okaya_RH320240T.h
  group Source/Devices/LCD/OKAYA/RV320240T
    ../../../../../../Source/Devices/LCD/OKAYA/RV320240T/: Okaya_rv320240t.c Okaya_RV320240T.h
  group Source/Devices/LCD/OKAYA/RV640480T
    ../../../../../../Source/Devices/LCD/OKAYA/RV640480T/: Okaya_RV640480T.c Okaya_RV640480T.h
  group Source/Devices/LCD/Seiko/43WQW1T
    ../../../../../../Source/Devices/LCD/Seiko/43WQW1T/: Seiko_43WQW1T.c Seiko_43WQW1T.h
  group Source/Devices/LCD/Seiko/70WVW2T
    ../../../../../../Source/Devices/LCD/Seiko/70WVW2T/: Seiko_70WVW2T.c Seiko_70WVW2T.h
  group Source/Devices/LCD/Sharp/LQ043T1DG01
    ../../../../../../Source/Devices/LCD/Sharp/LQ043T1DG01/: Sharp_LQ043T1DG01.c Sharp_LQ043T1DG01.h
  group Source/Devices/LCD/Sharp/LQ043T1DG28
    ../../../../../../Source/Devices/LCD/Sharp/LQ043T1DG28/: Sharp_LQ043T1DG28.c Sharp_LQ043T1DG28.h
  group Source/Devices/LCD/Sharp/LQ043T3DG02
    ../../../../../../Source/Devices/LCD/Sharp/LQ043T3DG02/: Sharp_LQ043T3DG02.c Sharp_LQ043T3DG02.h
  group Source/Devices/LCD/Tianma/TM043NBH02
    ../../../../../../Source/Devices/LCD/Tianma/TM043NBH02/: Tianma_TM043NBH02.c Tianma_TM043NBH02.h
  group Source/Devices/LCD/Tianma/TM047NBH01
    ../../../../../../Source/Devices/LCD/Tianma/TM047NBH01/: Tianma_TM047NBH01.c Tianma_TM047NBH01.h
  group Source/Devices/LCD/Tianma/TM070RBHG04
    ../../../../../../Source/Devices/LCD/Tianma/TM070RBHG04/: Tianma_TM070RBHG04.c Tianma_TM070RBHG04.h
  group Source/Devices/LCD/Toshiba/LTA057A347F
    ../../../../../../Source/Devices/LCD/Toshiba/LTA057A347F/: Toshiba_LTA057A347F.c Toshiba_LTA057A347F.h
  group Source/Devices/LED/Generic/GPIO
    ../../../../../../Source/Devices/LED/Generic/GPIO/: LED_Generic_GPIO.c LED_Generic_GPIO.h
  group Source/Devices/LED/NXP/PCA9551
    ../../../../../../Source/Devices/LED/NXP/PCA9551/: LED_NXP_PCA9551_driver.c
  group Source/Devices/Mass Storage/SDCard
    ../../../../../../Source/Devices/MassStorage/SDCard/: SDCard_MS_driver_MCI.c SDCard_MS_driver_SPI.c
  group Source/Devices/Mass Storage/USB_MS
    ../../../../../../Source/Devices/MassStorage/USB_MS/: USBMS_driver.c
  group Source/Devices/Network/Gainspan
    ../../../../../../Source/Devices/Network/GainSpan/: Network_GainSpan.c Network_GainSpan.h
  group Source/Devices/Network/lwIP
    ../../../../../../Source/Devices/Network/lwIP/: Network_lwIP.c
  group Source/Devices/Network/Redpine/RS9110_N_11_22
    ../../../../../../Source/Devices/Network/Redpine/RS9110_N_11_22/: includes.h internals.h network_config.c network_config.h process_data.c process_data.h Redpine_RS9110_N_11_22.h Redpine_RS9110_N_11_22_driver.c rs22_firmware.h rs22_spi_bus.c rs22_spi_pine.c rs22_ssp_hcd.c rsi_api.h rsi_compiler.h rsi_nic.h rsi_spi.c rsi_spi.h rsi_util.c rsi_util.h
  group Source/Devices/PWM/Generic
    ../../../../../../Source/Devices/PWM/Generic/: Generic_PWM.c
  group Source/Devices/RTC/Generic
    ../../../../../../Source/Devices/RTC/Generic/: generic_rtc.c
  group Source/Devices/RTC/NXP/PCF2129
    ../../../../../../Source/Devices/RTC/NXP/PCF2129/: RTC_PCF2129.c RTC_PCF2129.h
  group Source/Devices/RTC/NXP/PCF8563
    ../../../../../../Source/Devices/RTC/NXP/PCF8563/: RTC_PCF8563.c RTC_PCF8563.h
  group Source/Devices/Serial/Generic
    ../../../../../../Source/Devices/Serial/Generic/: uEZSerialGeneric.c uEZSerialGenericHalfDuplex.c
  group Source/Devices/Serial/RS485/Generic
    ../../../../../../Source/Devices/Serial/RS485/Generic/: Generic_RS485.c Generic_RS485.h Generic_RS485_Timer.c Generic_RS485_Timer.h
  group Source/Devices/SPI/Generic
    ../../../../../../Source/Devices/SPI/Generic/: Generic_spi.c Generic_SPI.h
  group Source/Devices/Temperature/Analog Devices/ADT7420
    ../../../../../../Source/Devices/Temperature/Analog Devices/ADT7420/: Temperature_ADT7420.c Temperature_ADT7420.h
  group Source/Devices/Temperature/NXP/LM75A
    ../../../../../../Source/Devices/Temperature/NXP/LM75A/: Temperature_LM75A_driver.c
  group Source/Devices/Temperature/NXP/SA56004X
    ../../../../../../Source/Devices/Temperature/NXP/SA56004X/: Temperature_SA56004X.h Temperature_SA56004X_driver.c
  group Source/Devices/Timer/Generic
    ../../../../../../Source/Devices/Timer/Generic/: Timer_Generic.c Timer_Generic.h
  group Source/Devices/ToneGenerator/Generic/PWM
    ../../../../../../Source/Devices/ToneGenerator/Generic/PWM/: ToneGenerator_Generic_PWM_driver.c
  group Source/Devices/ToneGenerator/Generic/Timer
    ../../../../../../Source/Devices/ToneGenerator/Generic/Timer/: ToneGenerator_Generic_Timer.h ToneGenerator_Generic_Timer_driver.c
  group Source/Devices/Touchscreen/Generic/FourWireTouchResist
    ../../../../../../Source/Devices/Touchscreen/Generic/FourWireTouchResist/: FourWireTouchResist_TS.c FourWireTouchResist_TS.h
  group Source/Devices/Touchscreen/Himax/HX8526-A
    ../../../../../../Source/Devices/Touchscreen/Himax/HX8526-A/: HX8526-A_TouchScreen.c HX8526-A_TouchScreen.h
  group Source/Devices/Touchscreen/Newhaven/FT5306DE4
    ../../../../../../Source/Devices/Touchscreen/Newhaven/FT5306DE4/: FT5306DE4TouchScreen.c FT5306DE4TouchScreen.h
  group Source/Devices/Touchscreen/Sitronix/ST1232
    ../../../../../../Source/Devices/Touchscreen/Sitronix/ST1232/: ST1232TouchScreen.c ST1232TouchScreen.h
  group Source/Devices/USBDevice/NXP/LPC17xx_40xx
    ../../../../../../Source/Devices/USBDevice/NXP/LPC17xx_40xx/: LPC17xx_40xx_USBDevice.c
  group Source/Devices/USBHost/Generic
    ../../../../../../Source/Devices/USBHost/Generic/: Generic_USBHost.c
  group Source/Devices/Watchdog/Generic
    ../../../../../../Source/Devices/Watchdog/Generic/: Watchdog_Generic_driver.c
  group Source/Library/Audio/DAC
    ../../../../../../Source/Library/Audio/DAC/: UEZDACWavFile.c UEZDACWavFile.h
  group Source/Library/Console/FDICmd
    ../../../../../../Source/Library/Console/FDICmd/: FDICmd.c FDICmd.h
  group Source/Library/Console/FDICmd/Commands
    ../../../../../../Source/Library/Console/FDICmd/Commands/: FDICmd_AudioDAC.c FDICmd_AudioDAC.h FDICmd_File.c FDICmd_File.h FDICmd_I2C.c FDICmd_I2C.h FDICmd_WAVPlay.c FDICmd_WAVPlay.h
  group Source/Library/FileSystem/FATFS
    ../../../../../../Source/Library/FileSystem/FATFS/: diskio.c diskio.h ff.c ff.h integer.h rtc.c rtc.h uEZFileSystem_FATFS.c
  group Source/Library/Graphics/SWIM
    ../../../../../../Source/Library/Graphics/SWIM/: droidsansr32.c lpc_colors.h lpc_droidsansr14.c lpc_droidsansr14.h lpc_droidsansr76.c lpc_droidsansr76.h lpc_fonts.h lpc_helvr10.c lpc_helvr10.h lpc_rom8x16.c lpc_rom8x16.h lpc_rom8x8.c lpc_rom8x8.h lpc_swim.c lpc_swim.h lpc_swim_driver.c lpc_swim_driver.h lpc_swim_font.c lpc_swim_font.h lpc_swim_image.c lpc_swim_image.h lpc_types.h lpc_winfreesystem14x16.c lpc_winfreesystem14x16.h lpc_winfreesystem14x16_subset.c lpc_winfreesystem14x16_subset.h lpc_x5x7.c lpc_x5x7.h lpc_x6x13.c lpc_x6x13.h
  group Source/Library/GUI/FDI/SimpleUI
    ../../../../../../Source/Library/GUI/FDI/SimpleUI/: SimpleUI.h SimpleUI_Choices.c SimpleUI_Choices.h SimpleUI_DrawBitmap.c SimpleUI_DrawBitmap.h SimpleUI_Drawing.c SimpleUI_Drawing.h SimpleUI_Regions.c SimpleUI_Regions.h SimpleUI_Types.h SimpleUI_UtilityFunctions.c SimpleUI_UtilityFunctions.h
  group Source/Library/GUI/SEGGER/emWin
    ../../../../../../Source/Library/GUI/SEGGER/emWin/: BUTTON.h BUTTON_Private.h CHECKBOX.h CHECKBOX_Private.h DIALOG.h DIALOG_Intern.h DROPDOWN.h DROPDOWN_Private.h EDIT.h EDIT_Private.h FRAMEWIN.h FRAMEWIN_Private.h Global.h GRAPH.h GRAPH_Private.h GUI.h GUI_ARRAY.h GUI_ARRAY_Private.h GUI_BMP_Private.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_GIF_Private.h GUI_HOOK.h GUI_JPEG_Private.h GUI_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_Type.h GUI_Version.h GUI_VNC.h GUIDRV_07X1.h GUIDRV_13700.h GUIDRV_13748.h GUIDRV_1611.h GUIDRV_6331.h GUIDRV_7529.h GUIDRV_BitPlains.h GUIDRV_CompactColor_16.h GUIDRV_Fujitsu_16.h GUIDRV_Generic.h GUIDRV_GW7630_1.h GUIDRV_IST3088.h GUIDRV_IST3088_Private.h GUIDRV_L5F30919.h GUIDRV_Lin.h GUIDRV_Lin_Private.h GUIDRV_NoOpt_1_8.h GUIDRV_Page1bpp.h GUIDRV_S1D13748.h GUIDRV_S1D13748_Private.h GUIDRV_S1D13U11.h GUIDRV_S1D15G00.h GUIDRV_SLin.h GUIDRV_SLin_Private.h GUIDRV_SSD1926.h GUIDRV_SSD1926_Private.h GUIDRV_Template.h GUIDRV_TemplateI.h GUIDRV_TemplateI_Private.h GUIDRV_UC1698G4.h HEADER.h HEADER_Private.h ICONVIEW.h ICONVIEW_Private.h LCD.h LCD_ConfDefaults.h LCD_Private.h LCD_Protected.h LCD_SIM.h LISTBOX.h LISTBOX_Private.h LISTVIEW.h LISTVIEW_Private.h LISTWHEEL.h LISTWHEEL_Private.h MENU.h MENU_Private.h MESSAGEBOX.h MULTIEDIT.h MULTIPAGE.h MULTIPAGE_Private.h PROGBAR.h PROGBAR_Private.h RADIO.h RADIO_Private.h SCROLLBAR.h SCROLLBAR_Private.h SLIDER.h SLIDER_Private.h TEXT.h TEXT_Private.h TREEVIEW.h TREEVIEW_Private.h WIDGET.h WINDOW_Private.h WM.h WM_GUI.h WM_Intern.h WM_Intern_ConfDep.h
  group Source/Library/Language/C
    ../../../../../../Source/Library/Language/C/: C.h itoa.c ltoa.c ultoa.c
  group Source/Library/lwIP
    ../../../../../../Source/Library/lwIP/: uEZEMAC_lwIP.c
  group Source/Library/lwIP/src/api
    ../../../../../../Source/Library/lwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Source/Library/lwIP/src/arch
    ../../../../../../Source/Library/lwIP/src/arch/: bpstruct.h cc.h clock.c clock.h epstruct.h ethernetif.h lwIP_EMAC.h perf.h sys_arch.c sys_arch.h
  group Source/Library/lwIP/src/core
    ../../../../../../Source/Library/lwIP/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group Source/Library/lwIP/src/core/ipv4
    ../../../../../../Source/Library/lwIP/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group Source/Library/lwIP/src/core/snmp
    ../../../../../../Source/Library/lwIP/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
  group Source/Library/lwIP/src/include/ipv4/lwip
    ../../../../../../Source/Library/lwIP/src/include/ipv4/lwip/: autoip.h icmp.h igmp.h inet.h inet_chksum.h ip.h ip_addr.h ip_frag.h
  group Source/Library/lwIP/src/include/ipv6/lwip
    ../../../../../../Source/Library/lwIP/src/include/ipv6/lwip/: icmp.h inet.h ip.h ip_addr.h
  group Source/Library/lwIP/src/include/lwip
    ../../../../../../Source/Library/lwIP/src/include/lwip/: api.h api_msg.h arch.h debug.h def.h dhcp.h dns.h err.h init.h mem.h memp.h memp_std.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h snmp_asn1.h snmp_msg.h snmp_structs.h sockets.h stats.h sys.h tcp.h tcpip.h udp.h
  group Source/Library/lwIP/src/include/netif
    ../../../../../../Source/Library/lwIP/src/include/netif/: etharp.h loopif.h ppp_oe.h slipif.h
  group Source/Library/lwIP/src/netif
    ../../../../../../Source/Library/lwIP/src/netif/: etharp.c ethernetif.c loopif.c slipif.c
  group Source/Library/lwIP/src/netif/ppp
    ../../../../../../Source/Library/lwIP/src/netif/ppp/: auth.c auth.h chap.c chap.h chpms.c chpms.h fsm.c fsm.h ipcp.c ipcp.h lcp.c lcp.h magic.c magic.h md5.c md5.h pap.c pap.h ppp.c ppp.h ppp_oe.c pppdebug.h randm.c randm.h vj.c vj.h vjbsdhdr.h
  group Source/Library/Memory/MemoryTest
    ../../../../../../Source/Library/Memory/MemoryTest/: MemoryTest.c MemoryTest.h
  group Source/Library/Network/GainSpan/CmdLib
    ../../../../../../Source/Library/Network/GainSpan/CmdLib/: AtCmdLib.c AtCmdLib.h GainSpan_CmdLib.c GainSpan_CmdLib.h GainSpan_SPI.c GainSpan_SPI.h
  group Source/Library/Network/PHY/MDIOBitBang
    ../../../../../../Source/Library/Network/PHY/MDIOBitBang/: MDIOBitBang.c MDIOBitBang.h
  group Source/Library/Parser/IntelHexParser
    ../../../../../../Source/Library/Parser/IntelHexParser/: IntelHexParser.c IntelHexParser.h
  group Source/Library/ScreenSaver
    ../../../../../../Source/Library/ScreenSaver/: BouncingLogoSS.c BouncingLogoSS.h
  group Source/Library/StreamIO/StdInOut
    ../../../../../../Source/Library/StreamIO/StdInOut/: StdInOut.c StdInOut.h
  group Source/Library/StreamIO/StdInOut/IAR
    ../../../../../../Source/Library/StreamIO/StdInOut/IAR/: StdInOut_IAR.c
  group Source/Library/Tests/ALS/Vishay/VCNL4010
    ../../../../../../Source/Library/Tests/ALS/Vishay/VCNL4010/: TestVCNL4010.c TestVCNL4010.h
  group Source/Library/uEZFailure
    ../../../../../../Source/Library/uEZFailure/: FatalError.c FatalError.h uEZFailure.c uEZFailure.h
  group Source/Library/USBDevice/MassStorage/Generic
    ../../../../../../Source/Library/USBDevice/MassStorage/Generic/: USBMSDrive.c USBMSDrive.h
  group Source/Library/Web/BasicWeb
    ../../../../../../Source/Library/Web/BasicWeb/: BasicWEB.c BasicWEB.h
  group Source/Library/Web/HTTPServer
    ../../../../../../Source/Library/Web/HTTPServer/: HTTPServer.c HTTPServer.h
  group Source/Platform/emWin
    ../../../../../../Source/Platform/emWin/: GUI_X_uEZ.c
  group Source/Platform/emWin/Config
    ../../../../../../Source/Platform/emWin/Config/: GUIConf.c GUIConf.h LCDConf.c LCDConf.h
  group Source/Platform/emWin/Inc
    ../../../../../../Source/Platform/emWin/Inc/: SEGGER.h
  group Source/Processor/NXP/LPC17xx_40xx
    ../../../../../../Source/Processor/NXP/LPC17xx_40xx/: Config_Processor.h LPC17xx_40xx_ADCBank.c LPC17xx_40xx_ADCBank.h LPC17xx_40xx_BatteryRAM.c LPC17xx_40xx_BatteryRAM.h LPC17xx_40xx_CRC.c LPC17xx_40xx_CRC.h LPC17xx_40xx_DAC.c LPC17xx_40xx_DAC.h LPC17xx_40xx_EMAC.c LPC17xx_40xx_EMAC.h LPC17xx_40xx_EMC_Static.c LPC17xx_40xx_EMC_Static.h LPC17xx_40xx_ExternalBus.c LPC17xx_40xx_ExternalBus.h LPC17xx_40xx_GPDMA.c LPC17xx_40xx_GPDMA.h LPC17xx_40xx_GPIO.c LPC17xx_40xx_GPIO.h LPC17xx_40xx_HALInit.c LPC17xx_40xx_I2C.c LPC17xx_40xx_I2C.h LPC17xx_40xx_I2S.c LPC17xx_40xx_I2S.h LPC17xx_40xx_Interrupt.c LPC17xx_40xx_LCDController.c LPC17xx_40xx_LCDController.h LPC17xx_40xx_MCI.c LPC17xx_40xx_PLL.c LPC17xx_40xx_PLL.h LPC17xx_40xx_PWM.c LPC17xx_40xx_PWM.h LPC17xx_40xx_RTC.c LPC17xx_40xx_RTC.h LPC17xx_40xx_SDRAM.c LPC17xx_40xx_SDRAM.h LPC17xx_40xx_Serial.c LPC17xx_40xx_Serial.h LPC17xx_40xx_SSP.c LPC17xx_40xx_SSP.h LPC17xx_40xx_Timer.c LPC17xx_40xx_Timer.h LPC17xx_40xx_USBDeviceController.c LPC17xx_40xx_USBDeviceController.h LPC17xx_40xx_USBHost.c LPC17xx_40xx_USBSharedInterrupt.c LPC17xx_40xx_UtilityFuncs.c LPC17xx_40xx_UtilityFuncs.h LPC17xx_40xx_Watchdog.c LPC17xx_40xx_Watchdog.h uEZProcessor_LPC17xx_40xx.h
    ../../../../../../Source/Processor/NXP/LPC17xx_40xx/IAR/include/CMSIS/: startup_LPC17xx.s
  group Source/RTOS
    ../../../../../../Source/RTOS/: uEZRTOS.c
  group Source/RTOS/FreeRTOS
    ../../../../../../Source/RTOS/FreeRTOS/: list.c queue.c tasks.c timers.c
  group Source/RTOS/FreeRTOS/include
    ../../../../../../Source/RTOS/FreeRTOS/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h
  group Source/RTOS/FreeRTOS/portable/IAR/ARM_CM3
    ../../../../../../Source/RTOS/FreeRTOS/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group Source/RTOS/FreeRTOS/portable/MemMang
    ../../../../../../Source/RTOS/FreeRTOS/portable/MemMang/: heap_3.c
  group Source/RTOS/FreeRTOS-Plus/FreeRTOS-Plus-Trace
    ../../../../../../Source/RTOS/FreeRTOS-Plus/FreeRTOS-Plus-Trace/: trcBase.c trcHardwarePort.c trcKernel.c trcKernelPort.c trcUser.c
  group Source/RTOS/FreeRTOS-Plus/FreeRTOS-Plus-Trace/Include
    ../../../../../../Source/RTOS/FreeRTOS-Plus/FreeRTOS-Plus-Trace/Include/: trcBase.h trcConfig.h trcHardwarePort.h trcKernel.h trcKernelHooks.h trcKernelPort.h trcTypes.h trcUser.h
  group Source/uEZSystem
    ../../../../../../Source/uEZSystem/: HAL.c uEZAccelerometer.c uEZADC.c uEZAudioAmp.c uEZAudioMixer.c uEZBSPInit.c uEZButton.c uEZCharDisplay.c uEZCRC.c uEZDAC.c uEZDeviceTable.c uEZEEPROM.c uEZEINT.c uEZFile.c uEZFlash.c uEZGPIO.c uEZHandles.c uEZHandles.h uEZHID.c uEZI2C.c uEZINI.c uEZInit.c uEZKeypad.c uEZLCD.c uEZLEDBank.c uEZMemory.c uEZNetwork.c uEZPWM.c uEZRandom.c uEZResourceCache.c uEZSPI.c uEZStream.c uEZTemperature.c uEZTimeDate.c uEZTimer.c uEZToneGenerator.c uEZTS.c uEZWatchdog.c uEZWAVFile.c
