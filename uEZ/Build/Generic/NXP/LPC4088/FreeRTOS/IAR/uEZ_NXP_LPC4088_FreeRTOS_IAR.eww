<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\uEZ_NXP_LPC4088_FreeRTOS_IAR.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>uEZ_NXP_LPC4088_FreeRTOS_IAR</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>uEZ_NXP_LPC4088_FreeRTOS_IAR</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>uEZ_NXP_LPC4088_FreeRTOS_IAR</project>
                <configuration>Release-Bootloader</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
