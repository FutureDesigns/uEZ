# IAR project uEZ_NXP_LPC4088_FreeRTOS_IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC4088 NXP LPC4088
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: LWIP_PROVIDE_ERRNO; UEZ_LIBRARY; CORE_M4; DEBUG; __FPU_PRESENT=1
  ICCARM.CCDiagSuppress: Pe193,Pe826,Pe068,Pa091
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: .; ../.; ../../../../../../.; ../../../../../../Include; ../../../../../../Source/RTOS/FreeRTOS/include; ../../../../../../Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../../../Source/RTOS/FreeRTOS-Plus/FreeRTOS-Plus-TCP/source/include; ../../../../../../Source/Processor/NXP/LPC17xx_40xx; ../../../../../../Source/Processor/NXP/LPC17xx_40xx/IAR/; ../../../../../../Source/Processor/NXP/LPC17xx_40xx/Common/include; ../../../../../../Source/Processor/ARM/CMSIS/Include; ../../../../../../Source/Processor/ARM/DSP/Include; ../../../../../../Source/RTOS/FreeRTOS/include; ../../../../../../Source/RTOS/FreeRTOS/; ../../../../../../Source/Library/Encryption/mbedtls/include; ../../../../../../Source/Library/Encryption/mbedtls; ../../../../../../Source/Library/lwIP/src/include; ../../../../../../Source/Library/lwIP/src; ../../../../../../Source/Library/lwIP/Include; ../../../../../../Source/Library/lwIP/src/include/ipv4; ../../../../../../Source/Library/lwIP/system; ../../../../../../Source/Library/lwIP/system/arch; ../../../../../../Source/Platform/emWin/Inc; ../../../../../../Source/Platform/emWin/Config; ../../../../../../Source/Library/GUI/SEGGER/emWin; ../../../../../../Source/Library/SEGGER/SystemView/; ../../../../../../Source/Library/SEGGER/RTT/; ../../../../../../Source/Library/Encryption/wolfSSL; ../../../../../../Source/Library/Encryption/wolfSSL/wolfssl; ../../../../../../Source/Library/Encryption/wolfSSL/ctaocrypt; ../../../../../../Source/Library/Encryption/wolfSSL/cyassl/openssl; ../../../../../../Source/Library/Network/wolfMQTT/
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M4; DEBUG
  AARM.AUserIncludes: .; ../.; ../../../../../../.; ../../../../../../Include; ../../../../../../Source/Processor/NXP/LPC17xx_40xx; ../../../../../../Source/Processor/NXP/LPC17xx_40xx/Common/include; ../../../../../../Source/Processor/ARM/CMSIS/Include; ../../../../../../Source/Processor/ARM/DSP/Include; ../../../../../../Source/RTOS/FreeRTOS/include; ../../../../../../Source/RTOS/FreeRTOS; ../../../../../../Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../../../Source/Library/lwIP/src/include; ../../../../../../Source/Library/lwIP/src; ../../../../../../Source/Library/lwIP/Include; ../../../../../../Source/Library/lwIP/src/include/ipv4; ../../../../../../Source/Library/lwIP/system; ../../../../../../Source/Library/lwIP/system/arch; ../../../../../../Source/Library/Encryption/wolfSSL; ../../../../../../Source/Library/Encryption/wolfSSL/wolfssl; ../../../../../../Source/Library/Encryption/wolfSSL/ctaocrypt; ../../../../../../Source/Library/Encryption/wolfSSL/cyassl/openssl
  OBJCOPY.OOCOutputFile: UEZGUIDemo.hex
  ILINK.IlinkOutputFile: UEZGUIDemo.out
  ILINK.IlinkIcfFile: uEZGUI_1788.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: LWIP_PROVIDE_ERRNO; UEZ_LIBRARY; CORE_M4; NDEBUG; __FPU_PRESENT=1
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: CORE_M4; NDEBUG
configuration Release-Bootloader (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: UEZ_LIBRARY; CORE_M4; NDEBUG; __FPU_PRESENT=1; DISABLE_FILESYSTEM_FORMAT_SUPPORT=1; DISABLE_FEATURES_FOR_BOOTLOADER=1
  ICCARM.CCIncludePath2: .; ../.; ../../../../../../.; ../../../../../../Include; ../../../../../../Source/RTOS/FreeRTOS/include; ../../../../../../Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../../../Source/RTOS/FreeRTOS-Plus/FreeRTOS-Plus-TCP/source/include; ../../../../../../Source/Processor/NXP/LPC17xx_40xx; ../../../../../../Source/Processor/NXP/LPC17xx_40xx/IAR/; ../../../../../../Source/Processor/NXP/LPC17xx_40xx/Common/include; ../../../../../../Source/Processor/ARM/CMSIS/Include; ../../../../../../Source/Processor/ARM/DSP/Include; ../../../../../../Source/RTOS/FreeRTOS/; ../../../../../../Source/Library/Encryption/mbedtls/include; ../../../../../../Source/Library/Encryption/mbedtls; ../../../../../../Source/Library/lwIP/src/include; ../../../../../../Source/Library/lwIP/src; ../../../../../../Source/Library/lwIP/Include; ../../../../../../Source/Library/lwIP/src/include/ipv4; ../../../../../../Source/Library/lwIP/system; ../../../../../../Source/Library/lwIP/system/arch; ../../../../../../Source/Platform/emWin/Inc; ../../../../../../Source/Platform/emWin/Config; ../../../../../../Source/Library/GUI/SEGGER/emWin; ../../../../../../Source/Library/SEGGER/SystemView/; ../../../../../../Source/Library/SEGGER/RTT/; ../../../../../../Source/Library/Encryption/wolfSSL; ../../../../../../Source/Library/Encryption/wolfSSL/wolfssl; ../../../../../../Source/Library/Encryption/wolfSSL/ctaocrypt; ../../../../../../Source/Library/Encryption/wolfSSL/cyassl/openssl; ../../../../../../Source/Library/Network/wolfMQTT/
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: CORE_M4; NDEBUG
  AARM.AUserIncludes: .; ../.; ../../../../../../.; ../../../../../../Include; ../../../../../../Source/Processor/NXP/LPC17xx_40xx; ../../../../../../Source/Processor/NXP/LPC17xx_40xx/Common/include; ../../../../../../Source/Processor/ARM/CMSIS/Include; ../../../../../../Source/Processor/ARM/DSP/Include; ../../../../../../Source/RTOS/FreeRTOS/include; ../../../../../../Source/RTOS/FreeRTOS/; ../../../../../../Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../../../Source/Library/lwIP/src/include; ../../../../../../Source/Library/lwIP/src; ../../../../../../Source/Library/lwIP/Include; ../../../../../../Source/Library/lwIP/src/include/ipv4; ../../../../../../Source/Library/lwIP/system; ../../../../../../Source/Library/lwIP/system/arch; ../../../../../../Source/Library/Encryption/wolfSSL; ../../../../../../Source/Library/Encryption/wolfSSL/wolfssl; ../../../../../../Source/Library/Encryption/wolfSSL/ctaocrypt; ../../../../../../Source/Library/Encryption/wolfSSL/cyassl/openssl
  group (top)
    ../: Config_Build.h
    ../../../../../../Source/RTOS/FreeRTOS/include/: FreeRTOSConfig.h
    ../../../../../../Include/: SEGGER_RTT_SYSVIEW_Config.h
    ./: uEZPlatform.h
  group Include
    ../../../../../../Include/: build_time.h Config.h core_http_config.h core_mqtt_agent_config.h core_mqtt_config.h core_pkcs11_config.h core_sntp_config.h defender_config.h fcntl.h FreeRTOSIPConfig.h Global.h lwipopts.h lwippools.h mbedtls_config.h mbedtls_crypto_config.h netdb.h pack_struct_end.h pack_struct_start.h shadow_config.h signal.h threading_alt.h uEZ.h uEZAccelerometer.h uEZADC.h uEZAudioAmp.h uEZAudioMixer.h uEZBSP.h uEZButton.h uEZCAN.h uEZCharDisplay.h uEZCRC.h uEZDAC.h uEZDevice.h uEZDeviceTable.h uEZEEPROM.h uEZEINT.h uEZErrors.h uEZFile.h uEZFlash.h uEZGPIO.h uEZHID.h uEZI2C.h uEZINI.h uEZInline.h uEZKeypad.h uEZLCD.h uEZLEDBank.h uEZMemory.h uEZNetwork.h uEZPacked.h uEZPlatformAPI.h uEZProcessor.h uEZPWM.h uEZRandom.h uEZResourceCache.h uEZRTOS.h uEZSPI.h uEZStream.h uEZTemperature.h uEZTickCounter.h uEZTimeDate.h uEZTimer.h uEZToneGenerator.h uEZTS.h uEZTypes.h uEZWatchdog.h uEZWAVFile.h unistd.h user_settings.h
  group Include/Device
    ../../../../../../Include/Device/: Accelerometer.h ADCBank.h AudioAmp.h AudioCodec.h Backlight.h ButtonBank.h CharDisplay.h DAC.h EEPROM.h ExternalInterrupt.h FileSystem.h Flash.h GPDMA.h HID.h I2CBus.h I2S.h Keypad.h LCD.h LEDBank.h LightSensor.h MassStorage.h Network.h PWM.h ResourceCache.h RTC.h SPIBus.h Stream.h Temperature.h Timer.h ToneGenerator.h Touchscreen.h USBDevice.h USBHost.h Watchdog.h
  group Include/Device/LCD
    ../../../../../../Include/Device/LCD/: Config_LCD.h
  group Include/HAL
    ../../../../../../Include/HAL/: ADCBank.h BatteryRAM.h CRC.h DAC.h EEPROM.h EMAC.h ExternalInterrupt.h GPDMA.h GPIO.h HAL.h I2CBus.h I2SBus.h Interrupt.h LCDController.h PWM.h RTC.h Serial.h SPI.h Timer.h USBDeviceController.h USBHost.h Watchdog.h
  group Include/netinet
    ../../../../../../Include/netinet/: in.h
  group Include/sys
    ../../../../../../Include/sys/: mman.h socket.h stat.h time.h types.h
  group Include/Types
    ../../../../../../Include/Types/: Accelerometer.h ADC.h CRC.h EEPROM.h EINT.h EMAC.h File.h Flash.h GPDMA.h GPIO.h I2C.h I2S.h InputEvent.h LCD.h Network.h SDRAM.h Serial.h SPI.h TimeDate.h Timer.h USBDevice.h USBHost.h WAVFile.h
  group Source/Devices/Accelerometer/Analog Devices/ADXL345
    ../../../../../../Source/Devices/Accelerometer/Analog Devices/ADXL345/: Accelerometer_ADXL345.c Accelerometer_ADXL345.h
  group Source/Devices/Accelerometer/Bosch/BMA150
    ../../../../../../Source/Devices/Accelerometer/Bosch/BMA150/: Bosch_BMA150_I2C.h Bosch_BMA150_I2C_driver.c
  group Source/Devices/Accelerometer/Freescale/MMA7455
    ../../../../../../Source/Devices/Accelerometer/Freescale/MMA7455/: Freescale_MMA7455.h Freescale_MMA7455_driver.c
  group Source/Devices/Accelerometer/ST/LIS3DH
    ../../../../../../Source/Devices/Accelerometer/ST/LIS3DH/: ST_LIS3DH_I2C.h ST_LIS3DH_I2C_driver.c
  group Source/Devices/Accelerometer/ST/LIS3LV02DQ
    ../../../../../../Source/Devices/Accelerometer/ST/LIS3LV02DQ/: ST_LIS3LV02DQ_I2C.h ST_LIS3LV02DQ_I2C_driver.c
  group Source/Devices/ADC/Generic
    ../../../../../../Source/Devices/ADC/Generic/: Generic_adc.c
  group Source/Devices/Audio Codec/Wolfson/WM8731
    ../../../../../../Source/Devices/Audio Codec/Wolfson/WM8731/: AudioCodec_WM8731.c AudioCodec_WM8731.h
  group Source/Devices/AudioAmp/NXP/TDA8551_T
    ../../../../../../Source/Devices/AudioAmp/NXP/TDA8551_T/: AudioAmp_8551T.c
  group Source/Devices/AudioAmp/TI/LM48100
    ../../../../../../Source/Devices/AudioAmp/TI/LM48100/: AudioAmp_LM48100.c AudioAmp_LM48100.h
  group Source/Devices/AudioAmp/Wolfson/WM8731
    ../../../../../../Source/Devices/AudioAmp/Wolfson/WM8731/: AudioAmp_WM8731.c AudioAmp_WM8731.h
  group Source/Devices/Backlight/Generic/BacklightPWMControlled
    ../../../../../../Source/Devices/Backlight/Generic/BacklightPWMControlled/: BacklightPWMControlled.c
  group Source/Devices/Button/NXP/PCA9551
    ../../../../../../Source/Devices/Button/NXP/PCA9551/: Button_NXP_PCA9551_driver.c
  group Source/Devices/CAN/Generic
    ../../../../../../Source/Devices/CAN/Generic/: Generic_CAN.h uEZCANGeneric.c
  group Source/Devices/CRC/Generic
    ../../../../../../Source/Devices/CRC/Generic/: CRC_Generic.c
  group Source/Devices/DAC/Generic
    ../../../../../../Source/Devices/DAC/Generic/: DAC_Generic.c
  group Source/Devices/EEPROM/Generic/I2C
    ../../../../../../Source/Devices/EEPROM/Generic/I2C/: EEPROM16_Generic_I2C.h EEPROM16_Generic_I2C_driver.c EEPROM_Generic_I2C.h EEPROM_Generic_I2C_driver.c
  group Source/Devices/EEPROM/NXP/LPC17xx_40xx
    ../../../../../../Source/Devices/EEPROM/NXP/LPC17xx_40xx/: EEPROM_NXP_LPC17xx_40xx.c EEPROM_NXP_LPC17xx_40xx.h
  group Source/Devices/ExternalInterrupt/Generic
    ../../../../../../Source/Devices/ExternalInterrupt/Generic/: ExternalInterrupt_Generic.c ExternalInterrupt_Generic.h
  group Source/Devices/Flash/Micron/M25P80
    ../../../../../../Source/Devices/Flash/Micron/M25P80/: Micron_M25P80.c Micron_M25P80.h
  group Source/Devices/Flash/NXP/LPC17xx_40xx
    ../../../../../../Source/Devices/Flash/NXP/LPC17xx_40xx/: LPC17xx_40xx_IAP.c LPC17xx_40xx_IAP.h
  group Source/Devices/Flash/NXP/LPC_SPIFI_M4F
    ../../../../../../Source/Devices/Flash/NXP/LPC_SPIFI_M4F/: Flash_NXP_LPC_SPIFI_M4.h Flash_NXP_LPC_SPIFI_M4_driver.c spifilib_api.h spifilib_chiphw.h spifilib_dev.h spifilib_dev_common.c spifilib_fam_standard_cmd.c
  group Source/Devices/Flash/Spansion/S29GL
    ../../../../../../Source/Devices/Flash/Spansion/S29GL/: Flash_S29GL064N90_16bit.h Flash_S29GL064N90_16bit_driver.c
  group Source/Devices/GPDMA/Generic
    ../../../../../../Source/Devices/GPDMA/Generic/: Generic_GPDMA.c
  group Source/Devices/GPIO/I2C/PCF8574T
    ../../../../../../Source/Devices/GPIO/I2C/PCF8574T/: GPIO_PCF8574T.c GPIO_PCF8574T.h
  group Source/Devices/GPIO/I2C/PCF8575
    ../../../../../../Source/Devices/GPIO/I2C/PCF8575/: GPIO_PCF8575.c GPIO_PCF8575.h
  group Source/Devices/HID/Generic
    ../../../../../../Source/Devices/HID/Generic/: HID_Generic.c
  group Source/Devices/I2C/Generic
    ../../../../../../Source/Devices/I2C/Generic/: Generic_i2c.c
  group Source/Devices/I2C/Mux/PCA9546
    ../../../../../../Source/Devices/I2C/Mux/PCA9546/: I2C_Mux_PCA9546.c I2C_Mux_PCA9546.h
  group Source/Devices/I2S/Generic
    ../../../../../../Source/Devices/I2S/Generic/: Generic_i2s.c Generic_I2S.h
  group Source/Devices/Keypad/GPIO
    ../../../../../../Source/Devices/Keypad/GPIO/: Keypad_Generic_GPIO.c Keypad_Generic_GPIO.h
  group Source/Devices/Keypad/NXP/I2C_Keypad
    ../../../../../../Source/Devices/Keypad/NXP/I2C_Keypad/: Keypad_NXP_I2C_PCA9555.h Keypad_NXP_I2C_PCA9555_driver.c
  group Source/Devices/LCD/DigitalImage/FG050720DSSWDG01
    ../../../../../../Source/Devices/LCD/DigitalImage/FG050720DSSWDG01/: LCD_DigitalImage_FG050720DSSWDG01.c LCD_DigitalImage_FG050720DSSWDG01.h
  group Source/Devices/LCD/DLC/DLC0430BCP12RF
    ../../../../../../Source/Devices/LCD/DLC/DLC0430BCP12RF/: DLC0430BCP12RF.c DLC0430BCP12RF.h
  group Source/Devices/LCD/DLC/DLC0430DCP15RF
    ../../../../../../Source/Devices/LCD/DLC/DLC0430DCP15RF/: DLC0430DCP15RF.c DLC0430DCP15RF.h
  group Source/Devices/LCD/Generic/Generic_480x272
    ../../../../../../Source/Devices/LCD/Generic/: Generic_480x272.c Generic_480x272.h
  group Source/Devices/LCD/Hitachi/TX11D06VM2APA
    ../../../../../../Source/Devices/LCD/Hitachi/TX11D06VM2APA/: Hitachi_TX11D06VM2APA.c Hitachi_TX11D06VM2APA.h
  group Source/Devices/LCD/Inteltronic/LMIX0560NTN53V1
    ../../../../../../Source/Devices/LCD/Inteltronic/LMIX0560NTN53V1/: Inteltronic_LMIX0560NTN53V1.c Inteltronic_LMIX0560NTN53V1.h
  group Source/Devices/LCD/Inteltronic/LMTDA043ZHN3
    ../../../../../../Source/Devices/LCD/Inteltronic/LMTDA043ZHN3/: LMTDA043ZHN3.c LMTDA043ZHN3.h
  group Source/Devices/LCD/Microtips/UMSH-8596MD-20T
    ../../../../../../Source/Devices/LCD/MicroTips/UMSH-8596MD-20T/: Microtips_UMSH_8596MD_20T.c Microtips_UMSH_8596MD_20T.h
  group Source/Devices/LCD/NEC/NL6448BC18-03F
    ../../../../../../Source/Devices/LCD/NEC/NL6448BC18-03F/: NEC-NL6448Bc18.c NEC-NL6448BC18.h
  group Source/Devices/LCD/Newhaven/NHD43480272CF
    ../../../../../../Source/Devices/LCD/NewHaven/NHD43800480CF/: NewHaven_NHD43800480CF.c NewHaven_NHD43800480CF.h
  group Source/Devices/LCD/Newhaven/NHD43480272EF-ASXP
    ../../../../../../Source/Devices/LCD/NewHaven/NHD43480272EF-ASXP/: NewHaven_NHD43480272EF-ASXP.c NewHaven_NHD43480272EF-ASXP.h
  group Source/Devices/LCD/Newhaven/NHD43480272EF-ASXV
    ../../../../../../Source/Devices/LCD/NewHaven/NHD43480272EF-ASXV/: NewHaven_NHD43480272EF-ASXV.c NewHaven_NHD43480272EF-ASXV.h
  group Source/Devices/LCD/Newhaven/NHD43480272MF
    ../../../../../../Source/Devices/LCD/NewHaven/NHD43480272MF/: NewHaven_NHD43480272MF.c NewHaven_NHD43480272MF.h
  group Source/Devices/LCD/OKAYA/RH320240T
    ../../../../../../Source/Devices/LCD/OKAYA/RH320240T/: Okaya_rh320240t.c Okaya_RH320240T.h
  group Source/Devices/LCD/OKAYA/RV320240T
    ../../../../../../Source/Devices/LCD/OKAYA/RV320240T/: Okaya_rv320240t.c Okaya_RV320240T.h
  group Source/Devices/LCD/OKAYA/RV640480T
    ../../../../../../Source/Devices/LCD/OKAYA/RV640480T/: Okaya_RV640480T.c Okaya_RV640480T.h
  group Source/Devices/LCD/Orient/AFY480272B0_43
    ../../../../../../Source/Devices/LCD/OrientDisplay/AFY480272B0-4.3N12NTM/: Orient_AFY480272B0_43N12NTM.c Orient_AFY480272B0_43N12NTM.h
  group Source/Devices/LCD/Seiko/43WQW1T
    ../../../../../../Source/Devices/LCD/Seiko/43WQW1T/: Seiko_43WQW1T.c Seiko_43WQW1T.h
  group Source/Devices/LCD/Seiko/70WVW2T
    ../../../../../../Source/Devices/LCD/Seiko/70WVW2T/: Seiko_70WVW2T.c Seiko_70WVW2T.h
  group Source/Devices/LCD/Sharp/LQ043T1DG01
    ../../../../../../Source/Devices/LCD/Sharp/LQ043T1DG01/: Sharp_LQ043T1DG01.c Sharp_LQ043T1DG01.h
  group Source/Devices/LCD/Sharp/LQ043T1DG28
    ../../../../../../Source/Devices/LCD/Sharp/LQ043T1DG28/: Sharp_LQ043T1DG28.c Sharp_LQ043T1DG28.h
  group Source/Devices/LCD/Sharp/LQ043T3DG02
    ../../../../../../Source/Devices/LCD/Sharp/LQ043T3DG02/: Sharp_LQ043T3DG02.c Sharp_LQ043T3DG02.h
  group Source/Devices/LCD/Sharp/LQ070Y3LW01
    ../../../../../../Source/Devices/LCD/Sharp/LQ070Y3LW01/: Sharp_LQ070Y3LW01.c Sharp_LQ070Y3LW01.h
  group Source/Devices/LCD/Tianma/TM043NBH02
    ../../../../../../Source/Devices/LCD/Tianma/TM043NBH02/: Tianma_TM043NBH02.c Tianma_TM043NBH02.h
  group Source/Devices/LCD/Tianma/TM047NBH01
    ../../../../../../Source/Devices/LCD/Tianma/TM047NBH01/: Tianma_TM047NBH01.c Tianma_TM047NBH01.h
  group Source/Devices/LCD/Tianma/TM070RBHG04
    ../../../../../../Source/Devices/LCD/Tianma/TM070RBHG04/: Tianma_TM070RBHG04.c Tianma_TM070RBHG04.h
  group Source/Devices/LCD/Toshiba/LTA057A347F
    ../../../../../../Source/Devices/LCD/Toshiba/LTA057A347F/: Toshiba_LTA057A347F.c Toshiba_LTA057A347F.h
  group Source/Devices/LED/Generic/GPIO
    ../../../../../../Source/Devices/LED/Generic/GPIO/: LED_Generic_GPIO.c LED_Generic_GPIO.h
  group Source/Devices/LED/NXP/PCA9551
    ../../../../../../Source/Devices/LED/NXP/PCA9551/: LED_NXP_PCA9551_driver.c
  group Source/Devices/Mass Storage/SDCard
    ../../../../../../Source/Devices/MassStorage/SDCard/: SDCard_MS_driver_MCI.c SDCard_MS_driver_SPI.c
  group Source/Devices/Mass Storage/USB_MS
    ../../../../../../Source/Devices/MassStorage/USB_MS/: USBMS_driver.c
  group Source/Devices/Network/ESPWROOM32
    ../../../../../../Source/Devices/Network/ESPWROOM32/: Network_ESPWROOM32.c Network_ESPWROOM32.h
  group Source/Devices/Network/Gainspan
    ../../../../../../Source/Devices/Network/GainSpan/: Network_GainSpan.c Network_GainSpan.h
  group Source/Devices/Network/lwIP
    ../../../../../../Source/Devices/Network/lwIP/: Network_lwIP.c Network_lwIP.h
  group Source/Devices/PWM/Generic
    ../../../../../../Source/Devices/PWM/Generic/: Generic_PWM.c
  group Source/Devices/ResourceCache/Generic/DirectAccess
    ../../../../../../Source/Devices/ResourceCache/Generic/DirectAccess/: ResourceCache_DirectAccess.c ResourceCache_DirectAccess.h
  group Source/Devices/RTC/Generic
    ../../../../../../Source/Devices/RTC/Generic/: generic_rtc.c
  group Source/Devices/RTC/NXP/PCF2129
    ../../../../../../Source/Devices/RTC/NXP/PCF2129/: RTC_PCF2129.c RTC_PCF2129.h
  group Source/Devices/RTC/NXP/PCF8563
    ../../../../../../Source/Devices/RTC/NXP/PCF8563/: RTC_PCF8563.c RTC_PCF8563.h
  group Source/Devices/Serial/Generic
    ../../../../../../Source/Devices/Serial/Generic/: uEZSerialGeneric.c uEZSerialGenericHalfDuplex.c
  group Source/Devices/Serial/RS485/Generic
    ../../../../../../Source/Devices/Serial/RS485/Generic/: Generic_RS485.c Generic_RS485.h Generic_RS485_Timer.c Generic_RS485_Timer.h
  group Source/Devices/SPI/Generic
    ../../../../../../Source/Devices/SPI/Generic/: Generic_spi.c Generic_SPI.h
  group Source/Devices/Temperature/Analog Devices/ADT7420
    ../../../../../../Source/Devices/Temperature/Analog Devices/ADT7420/: Temperature_ADT7420.c Temperature_ADT7420.h
  group Source/Devices/Temperature/NXP/LM75A
    ../../../../../../Source/Devices/Temperature/NXP/LM75A/: Temperature_LM75A_driver.c
  group Source/Devices/Temperature/NXP/SA56004X
    ../../../../../../Source/Devices/Temperature/NXP/SA56004X/: Temperature_SA56004X.h Temperature_SA56004X_driver.c
  group Source/Devices/Timer/Generic
    ../../../../../../Source/Devices/Timer/Generic/: Timer_Generic.c Timer_Generic.h
  group Source/Devices/ToneGenerator/Generic/PWM
    ../../../../../../Source/Devices/ToneGenerator/Generic/PWM/: ToneGenerator_Generic_PWM_driver.c
  group Source/Devices/ToneGenerator/Generic/Timer
    ../../../../../../Source/Devices/ToneGenerator/Generic/Timer/: ToneGenerator_Generic_Timer.h ToneGenerator_Generic_Timer_driver.c
  group Source/Devices/Touchscreen/Generic/FourWireTouchResist
    ../../../../../../Source/Devices/Touchscreen/Generic/FourWireTouchResist/: FourWireTouchResist_TS.c FourWireTouchResist_TS.h
  group Source/Devices/Touchscreen/Himax/HX8526-A
    ../../../../../../Source/Devices/Touchscreen/Himax/HX8526-A/: HX8526-A_TouchScreen.c HX8526-A_TouchScreen.h
  group Source/Devices/Touchscreen/Newhaven/FT5306DE4
    ../../../../../../Source/Devices/Touchscreen/Newhaven/FT5306DE4/: FT5306DE4TouchScreen.c FT5306DE4TouchScreen.h
  group Source/Devices/Touchscreen/Semisense/SN2780MQ
    ../../../../../../Source/Devices/Touchscreen/Semisense/SN2780MQ/: SN2780MQTouchScreen.c SN2780MQTouchScreen.h
  group Source/Devices/Touchscreen/Sitronix/ST1232
    ../../../../../../Source/Devices/Touchscreen/Sitronix/ST1232/: ST1232TouchScreen.c ST1232TouchScreen.h
  group Source/Devices/USBDevice/NXP/LPC17xx_40xx
    ../../../../../../Source/Devices/USBDevice/NXP/LPC17xx_40xx/: LPC17xx_40xx_USBDevice.c
  group Source/Devices/USBHost/Generic
    ../../../../../../Source/Devices/USBHost/Generic/: Generic_USBHost.c
  group Source/Devices/Watchdog/Generic
    ../../../../../../Source/Devices/Watchdog/Generic/: Watchdog_Generic_driver.c
  group Source/Library/Audio/DAC
    ../../../../../../Source/Library/Audio/DAC/: uEZDACWAVFile.c uEZDACWAVFile.h
  group Source/Library/Console/FDICmd
    ../../../../../../Source/Library/Console/FDICmd/: FDICmd.c FDICmd.h
  group Source/Library/Console/FDICmd/Commands
    ../../../../../../Source/Library/Console/FDICmd/Commands/: FDICmd_AudioDAC.c FDICmd_AudioDAC.h FDICmd_File.c FDICmd_File.h FDICmd_I2C.c FDICmd_I2C.h FDICmd_WAVPlay.c FDICmd_WAVPlay.h
  group Source/Library/Encryption/mbedtls/include/mbedtls
    ../../../../../../Source/Library/Encryption/mbedtls/include/mbedtls/: aes.h aria.h asn1.h asn1write.h base64.h bignum.h block_cipher.h build_info.h camellia.h ccm.h chacha20.h chachapoly.h check_config.h cipher.h cmac.h compat-2.x.h config_adjust_legacy_crypto.h config_adjust_legacy_from_psa.h config_adjust_psa_from_legacy.h config_adjust_psa_superset_legacy.h config_adjust_ssl.h config_adjust_x509.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h error.h gcm.h hkdf.h hmac_drbg.h lms.h md.h md5.h memory_buffer_alloc.h net_sockets.h nist_kw.h oid.h pem.h pk.h pkcs12.h pkcs5.h pkcs7.h platform.h platform_time.h platform_util.h poly1305.h private_access.h psa_util.h ripemd160.h rsa.h sha1.h sha256.h sha3.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h
  group Source/Library/Encryption/mbedtls/include/psa
    ../../../../../../Source/Library/Encryption/mbedtls/include/psa/: build_info.h crypto.h crypto_adjust_auto_enabled.h crypto_adjust_config_dependencies.h crypto_adjust_config_key_pair_types.h crypto_adjust_config_synonyms.h crypto_builtin_composites.h crypto_builtin_key_derivation.h crypto_builtin_primitives.h crypto_compat.h crypto_driver_common.h crypto_driver_contexts_composites.h crypto_driver_contexts_key_derivation.h crypto_driver_contexts_primitives.h crypto_extra.h crypto_legacy.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group Source/Library/Encryption/mbedtls/library
    ../../../../../../Source/Library/Encryption/mbedtls/library/: aes.c aesce.c aesce.h aesni.c aesni.h alignment.h aria.c asn1parse.c asn1write.c base64.c base64_internal.h bignum.c bignum_core.c bignum_core.h bignum_internal.h bignum_mod.c bignum_mod.h bignum_mod_raw.c bignum_mod_raw.h bignum_mod_raw_invasive.h block_cipher.c block_cipher_internal.h bn_mul.h camellia.c ccm.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_wrap.c cipher_wrap.h cmac.c common.h constant_time.c constant_time_impl.h constant_time_internal.h ctr.h ctr_drbg.c debug.c debug_internal.h des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_curves_new.c ecp_internal_alt.h ecp_invasive.h entropy.c entropy_poll.c entropy_poll.h error.c gcm.c hkdf.c hmac_drbg.c lmots.c lmots.h lms.c Makefile md.c md5.c md_psa.h md_wrap.h memory_buffer_alloc.c mps_common.h mps_error.h mps_reader.c mps_reader.h mps_trace.c mps_trace.h net_sockets.c nist_kw.c oid.c padlock.c padlock.h pem.c pk.c pk_ecc.c pk_internal.h pk_wrap.c pk_wrap.h pkcs12.c pkcs5.c pkcs7.c pkparse.c pkwrite.c pkwrite.h platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_aead.h psa_crypto_cipher.c psa_crypto_cipher.h psa_crypto_client.c psa_crypto_core.h psa_crypto_core_common.h psa_crypto_driver_wrappers.h psa_crypto_driver_wrappers_no_static.c psa_crypto_driver_wrappers_no_static.h psa_crypto_ecp.c psa_crypto_ecp.h psa_crypto_ffdh.c psa_crypto_ffdh.h psa_crypto_hash.c psa_crypto_hash.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_mac.c psa_crypto_mac.h psa_crypto_pake.c psa_crypto_pake.h psa_crypto_random_impl.h psa_crypto_rsa.c psa_crypto_rsa.h psa_crypto_se.c psa_crypto_se.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_its_file.c psa_util.c psa_util_internal.h ripemd160.c rsa.c rsa_alt_helpers.c rsa_alt_helpers.h rsa_internal.h sha1.c sha256.c sha3.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_ciphersuites_internal.h ssl_client.c ssl_client.h ssl_cookie.c ssl_debug_helpers.h ssl_debug_helpers_generated.c ssl_misc.h ssl_msg.c ssl_ticket.c ssl_tls.c ssl_tls12_client.c ssl_tls12_server.c ssl_tls13_client.c ssl_tls13_generic.c ssl_tls13_invasive.h ssl_tls13_keys.c ssl_tls13_keys.h ssl_tls13_server.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509_internal.h x509write.c x509write_crt.c x509write_csr.c
  group Source/Library/Encryption/mbedtls/port
    ../../../../../../Source/Library/Encryption/mbedtls/port/: aes_alt.c aes_alt.h ccm_alt.h des_alt.c des_alt.h ecp_alt.c ecp_alt.h ecp_alt_ksdk.c ecp_curves_alt.c sha1_alt.h sha256_alt.h time_alt.h uez_mbedtls.c uez_mbedtls.h
  group Source/Library/Encryption/tls_basic_in_out_transport
    ../../../../../../Source/Library/Encryption/tls_basic_in_out_transport/: mbedtls_bio_tcp_sockets_wrapper.h mbedtls_bio_tcp_sockets_wrapper_uEZ.c tls_transport_mbedtls_pkcs11_FreeRTOS.c tls_transport_mbedtls_pkcs11_FreeRTOS.h
  group Source/Library/Encryption/wolfSSL/ctaocrypt/src
    ../../../../../../Source/Library/Encryption/wolfSSL/ctaocrypt/src/: aes.c des3.c hmac.c misc.c random.c rsa.c sha.c sha256.c sha512.c wolfcrypt_first.c wolfcrypt_last.c
  group Source/Library/Encryption/wolfSSL/src
    ../../../../../../Source/Library/Encryption/wolfSSL/src/: crl.c dtls.c dtls13.c internal.c keys.c ocsp.c quic.c sniffer.c ssl.c tls.c tls13.c wolfio.c
  group Source/Library/FileSystem/FATFS
    ../../../../../../Source/Library/FileSystem/FATFS/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c rtc.c rtc.h uEZFileSystem_FATFS.c uEZFileSystem_FATFS.h
  group Source/Library/Graphics/SWIM
    ../../../../../../Source/Library/Graphics/SWIM/: droidsansr32.c lpc_colors.h lpc_droidsansr14.c lpc_droidsansr14.h lpc_droidsansr76.c lpc_droidsansr76.h lpc_fonts.h lpc_helvr10.c lpc_helvr10.h lpc_rom8x16.c lpc_rom8x16.h lpc_rom8x8.c lpc_rom8x8.h lpc_swim.c lpc_swim.h lpc_swim_driver.c lpc_swim_driver.h lpc_swim_font.c lpc_swim_font.h lpc_swim_image.c lpc_swim_image.h lpc_types.h lpc_winfreesystem14x16.c lpc_winfreesystem14x16.h lpc_winfreesystem14x16_subset.c lpc_winfreesystem14x16_subset.h lpc_x5x7.c lpc_x5x7.h lpc_x6x13.c lpc_x6x13.h
  group Source/Library/GUI/FDI/SimpleUI
    ../../../../../../Source/Library/GUI/FDI/SimpleUI/: SimpleUI.h SimpleUI_Choices.c SimpleUI_Choices.h SimpleUI_DrawBitmap.c SimpleUI_DrawBitmap.h SimpleUI_Drawing.c SimpleUI_Drawing.h SimpleUI_Regions.c SimpleUI_Regions.h SimpleUI_Types.h SimpleUI_UtilityFunctions.c SimpleUI_UtilityFunctions.h
  group Source/Library/GUI/SEGGER/emWin
    ../../../../../../Source/Library/GUI/SEGGER/emWin/: AppWizard.h BUTTON.h BUTTON_Private.h CALENDAR.h CHECKBOX.h CHECKBOX_Private.h CHOOSECOLOR.h CHOOSEFILE.h DIALOG.h DIALOG_Type.h DROPDOWN.h DROPDOWN_Private.h EDIT.h EDIT_Private.h FRAMEWIN.h FRAMEWIN_Private.h GAUGE.h GAUGE_Private.h GRAPH.h GRAPH_Private.h GUI.h GUI_ARRAY.h GUI_ARRAY_Private.h GUI_BMP_Private.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_GCache_Private.h GUI_GIF_Private.h GUI_JPEG_Private.h GUI_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_SPRITE_Private.h GUI_SPY_Private.h GUI_Type.h GUI_Version.h GUI_VNC.h GUIDRV_BitPlains.h GUIDRV_DCache.h GUIDRV_DCache_Private.h GUIDRV_Dist.h GUIDRV_FlexColor.h GUIDRV_FlexColor_Private.h GUIDRV_IST3088.h GUIDRV_IST3088_Private.h GUIDRV_Lin.h GUIDRV_Lin_Opt_16.h GUIDRV_Lin_Opt_24.h GUIDRV_Lin_Opt_32.h GUIDRV_Lin_Opt_8.h GUIDRV_Lin_Private.h GUIDRV_NoOpt_1_8.h GUIDRV_S1D13748.h GUIDRV_S1D13748_Private.h GUIDRV_S1D13781.h GUIDRV_S1D13781_Private.h GUIDRV_S1D15G00.h GUIDRV_SH_MEM.h GUIDRV_SH_MEM_Private.h GUIDRV_SLin.h GUIDRV_SLin_Private.h GUIDRV_SPage.h GUIDRV_SPage_Private.h GUIDRV_SSD1926.h GUIDRV_SSD1926_Private.h GUITDRV_ADS7846.h HEADER.h HEADER_Private.h ICONVIEW.h ICONVIEW_Private.h IMAGE.h IMAGE_Private.h IP_FS.h KEYBOARD.h KEYBOARD_Private.h KNOB.h KNOB_Private.h LCD.h LCD_ConfDefaults.h LCD_Private.h LCD_Protected.h LCD_SIM.h LISTBOX.h LISTBOX_Private.h LISTVIEW.h LISTVIEW_Private.h LISTWHEEL.h LISTWHEEL_Private.h MENU.h MENU_Private.h MESSAGEBOX.h MULTIEDIT.h MULTIEDIT_Private.h MULTIPAGE.h MULTIPAGE_Private.h PROGBAR.h PROGBAR_Private.h QRCODE.h QRCODE_Private.h RADIO.h RADIO_Private.h ROTARY.h ROTARY_Private.h SCROLLBAR.h SCROLLBAR_Private.h SEGGER.h SLIDER.h SLIDER_Private.h SPINBOX.h SPINBOX_Private.h SWIPELIST.h SWIPELIST_Private.h SWITCH.h SWITCH_Private.h TEXT.h TEXT_Private.h TREEVIEW.h TREEVIEW_Private.h WIDGET.h WINDOW_Private.h WM.h WM_GUI.h WM_Intern.h
  group Source/Library/Language/C
    ../../../../../../Source/Library/Language/C/: C.h itoa.c ltoa.c ultoa.c
  group Source/Library/lwIP
    ../../../../../../Source/Library/lwIP/: emac.h uEZEMAC_lwIP.c
  group Source/Library/lwIP/contrib/addons/ipv6_static_routing
    ../../../../../../Source/Library/lwIP/contrib/addons/ipv6_static_routing/: ip6_route_table.c ip6_route_table.h
  group Source/Library/lwIP/contrib/examples/lwiperf
    ../../../../../../Source/Library/lwIP/contrib/examples/lwiperf/: lwiperf_example.c lwiperf_example.h
  group Source/Library/lwIP/contrib/examples/mdns
    ../../../../../../Source/Library/lwIP/contrib/examples/mdns/: mdns_example.c mdns_example.h
  group Source/Library/lwIP/contrib/examples/mqtt
    ../../../../../../Source/Library/lwIP/contrib/examples/mqtt/: mqtt_example.c mqtt_example.h
  group Source/Library/lwIP/contrib/examples/ppp
    ../../../../../../Source/Library/lwIP/contrib/examples/ppp/: pppos_example.c pppos_example.h
  group Source/Library/lwIP/contrib/examples/snmp
    ../../../../../../Source/Library/lwIP/contrib/examples/snmp/snmp_private_mib/: lwip_prvmib.c private_mib.h
    ../../../../../../Source/Library/lwIP/contrib/examples/snmp/: snmp_example.c snmp_example.h
    ../../../../../../Source/Library/lwIP/contrib/examples/snmp/snmp_v3/: snmpv3_dummy.c snmpv3_dummy.h
  group Source/Library/lwIP/contrib/examples/tftp
    ../../../../../../Source/Library/lwIP/contrib/examples/tftp/: tftp_example.c tftp_example.h
  group Source/Library/lwIP/src/api
    ../../../../../../Source/Library/lwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Source/Library/lwIP/src/apps/altcp_tls
    ../../../../../../Source/Library/lwIP/src/apps/altcp_tls/: altcp_tls_mbedtls.c altcp_tls_mbedtls_mem.c altcp_tls_mbedtls_mem.h altcp_tls_mbedtls_structs.h
  group Source/Library/lwIP/src/apps/http
    ../../../../../../Source/Library/lwIP/src/apps/http/: altcp_proxyconnect.c fs.c httpd.c
  group Source/Library/lwIP/src/apps/lwiperf
    ../../../../../../Source/Library/lwIP/src/apps/lwiperf/: lwiperf.c
  group Source/Library/lwIP/src/apps/mdns
    ../../../../../../Source/Library/lwIP/src/apps/mdns/: mdns.c mdns_domain.c mdns_out.c
  group Source/Library/lwIP/src/apps/mqtt
    ../../../../../../Source/Library/lwIP/src/apps/mqtt/: mqtt.c
  group Source/Library/lwIP/src/apps/netbiosns
    ../../../../../../Source/Library/lwIP/src/apps/netbiosns/: netbiosns.c
  group Source/Library/lwIP/src/apps/smtp
    ../../../../../../Source/Library/lwIP/src/apps/smtp/: smtp.c
  group Source/Library/lwIP/src/apps/snmp
    ../../../../../../Source/Library/lwIP/src/apps/snmp/: snmp_asn1.c snmp_asn1.h snmp_core.c snmp_core_priv.h snmp_mib2.c snmp_mib2_icmp.c snmp_mib2_interfaces.c snmp_mib2_ip.c snmp_mib2_snmp.c snmp_mib2_system.c snmp_mib2_tcp.c snmp_mib2_udp.c snmp_msg.c snmp_msg.h snmp_netconn.c snmp_pbuf_stream.c snmp_pbuf_stream.h snmp_raw.c snmp_scalar.c snmp_snmpv2_framework.c snmp_snmpv2_usm.c snmp_table.c snmp_threadsync.c snmp_traps.c snmpv3.c snmpv3_mbedtls.c snmpv3_priv.h
  group Source/Library/lwIP/src/apps/sntp
    ../../../../../../Source/Library/lwIP/src/apps/sntp/: sntp.c
  group Source/Library/lwIP/src/apps/tftp
    ../../../../../../Source/Library/lwIP/src/apps/tftp/: tftp.c
  group Source/Library/lwIP/src/core
    ../../../../../../Source/Library/lwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Source/Library/lwIP/src/core/ipv4
    ../../../../../../Source/Library/lwIP/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Source/Library/lwIP/src/core/ipv6
    ../../../../../../Source/Library/lwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group Source/Library/lwIP/src/include/lwip
    ../../../../../../Source/Library/lwIP/src/include/lwip/: acd.h altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group Source/Library/lwIP/src/include/lwip/apps
    ../../../../../../Source/Library/lwIP/src/include/lwip/apps/: fs.h httpd.h httpd_opts.h lwiperf.h mdns.h mdns_opts.h mdns_priv.h mqtt.h mqtt_opts.h netbiosns.h netbiosns_opts.h snmp.h snmp_core.h snmp_mib2.h snmp_opts.h snmp_scalar.h snmp_table.h snmp_threadsync.h snmpv3.h sntp.h sntp_opts.h tftp_opts.h tftp_server.h
  group Source/Library/lwIP/src/include/lwip/priv
    ../../../../../../Source/Library/lwIP/src/include/lwip/priv/: api_msg.h memp_priv.h memp_std.h nd6_priv.h tcp_priv.h tcpip_priv.h
  group Source/Library/lwIP/src/include/lwip/prot
    ../../../../../../Source/Library/lwIP/src/include/lwip/prot/: autoip.h dhcp.h dns.h etharp.h ethernet.h icmp.h icmp6.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group Source/Library/lwIP/src/include/netif
    ../../../../../../Source/Library/lwIP/src/include/netif/: etharp.h ethernet.h lowpan6.h lowpan6_opts.h slipif.h
  group Source/Library/lwIP/src/include/netif/ppp
    ../../../../../../Source/Library/lwIP/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group Source/Library/lwIP/src/netif
    ../../../../../../Source/Library/lwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group Source/Library/lwIP/src/netif/ppp
    ../../../../../../Source/Library/lwIP/src/netif/ppp/polarssl/: arc4.c des.c md4.c md5.c sha1.c
    ../../../../../../Source/Library/lwIP/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group Source/Library/lwIP/system/arch
    ../../../../../../Source/Library/lwIP/system/arch/: bpstruct.h cc.h cpu.h epstruct.h init.h lib.h lwIP_EMAC.h perf.h sntp_uEZ.h sys_arch.h
  group Source/Library/lwIP/system/OS
    ../../../../../../Source/Library/lwIP/system/OS/: ethernetif_uEZ.c sntp_uEZ.c sys_arch.c
  group Source/Library/lwIP/test/sockets
    ../../../../../../Source/Library/lwIP/test/sockets/: sockets_stresstest.c sockets_stresstest.h
  group Source/Library/Memory/MemoryTest
    ../../../../../../Source/Library/Memory/MemoryTest/: MemoryTest.c MemoryTest.h
  group Source/Library/Network/GainSpan/CmdLib
    ../../../../../../Source/Library/Network/GainSpan/CmdLib/: AtCmdLib.c AtCmdLib.h GainSpan_CmdLib.c GainSpan_CmdLib.h GainSpan_SPI.c GainSpan_SPI.h
  group Source/Library/Network/lwip-ftpd
    ../../../../../../Source/Library/Network/lwip-ftpd/: ftpd.c ftpd.h vfs.c vfs.h
  group Source/Library/Network/PHY/MDIOBitBang
    ../../../../../../Source/Library/Network/PHY/MDIOBitBang/: MDIOBitBang.c MDIOBitBang.h
  group Source/Library/Network/wolfMQTT
    ../../../../../../Source/Library/Network/wolfMQTT/src/: mqtt_client.c mqtt_packet.c mqtt_socket.c
    ../../../../../../Source/Library/Network/wolfMQTT/wolfmqtt/: mqtt_client.h mqtt_packet.h mqtt_socket.h mqtt_types.h options.h version.h version.h.in visibility.h vs_settings.h
  group Source/Library/Parser/IntelHexParser
    ../../../../../../Source/Library/Parser/IntelHexParser/: IntelHexParser.c IntelHexParser.h
  group Source/Library/Random/simplerandom
    ../../../../../../Source/Library/Random/simplerandom/: simplerandom-c.h simplerandom.c simplerandom.h
  group Source/Library/ScreenSaver
    ../../../../../../Source/Library/ScreenSaver/: BouncingLogoSS.c BouncingLogoSS.h
  group Source/Library/SEGGER/RTT
    ../../../../../../Source/Library/SEGGER/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_ASM_ARMv7M.S SEGGER_RTT_Conf.h SEGGER_RTT_Printf.c SEGGER_RTT_Syscalls_IAR.c
  group Source/Library/SEGGER/SystemView
    ../../../../../../Source/Library/SEGGER/SystemView/: SEGGER.h SEGGER_SYSVIEW.c SEGGER_SYSVIEW.h SEGGER_SYSVIEW_Conf.h SEGGER_SYSVIEW_ConfDefaults.h SEGGER_SYSVIEW_Config_FreeRTOS.c SEGGER_SYSVIEW_FreeRTOS.c SEGGER_SYSVIEW_FreeRTOS.h SEGGER_SYSVIEW_Int.h
  group Source/Library/StreamIO/StdInOut
    ../../../../../../Source/Library/StreamIO/StdInOut/: StdInOut.c StdInOut.h
  group Source/Library/StreamIO/StdInOut/IAR
    ../../../../../../Source/Library/StreamIO/StdInOut/IAR/: StdInOut_IAR.c
  group Source/Library/Tests/ALS/Vishay/VCNL4010
    ../../../../../../Source/Library/Tests/ALS/Vishay/VCNL4010/: TestVCNL4010.c TestVCNL4010.h
  group Source/Library/uEZFailure
    ../../../../../../Source/Library/uEZFailure/: FatalError.c FatalError.h uEZFailure.c uEZFailure.h
  group Source/Library/USBDevice/Generic/VirtualComm
    ../../../../../../Source/Library/USBDevice/Generic/VirtualComm/: VirtualComm.c VirtualComm.h
  group Source/Library/USBDevice/MassStorage/Generic
    ../../../../../../Source/Library/USBDevice/MassStorage/Generic/: USBMSDrive.c USBMSDrive.h
  group Source/Library/Web/AWSIoTClient
    ../../../../../../Source/Library/Web/AWSIoTClient/: aws_clientcredential.h aws_clientcredential_keys.h aws_dev_mode_key_provisioning.c aws_dev_mode_key_provisioning.h AWSIoTClient.c AWSIoTClient.h iot_pkcs11_pal.c
  group Source/Library/Web/AWSIoTClient/aws_iot/iot-reference/examples
    ../../../../../../Source/Library/Web/AWSIoTClient/aws_iot/iot-reference/examples/common/kvstore/: kvstore.c kvstore.h
    ../../../../../../Source/Library/Web/AWSIoTClient/aws_iot/iot-reference/examples/common/logging/: logging.c logging.h
    ../../../../../../Source/Library/Web/AWSIoTClient/aws_iot/iot-reference/examples/common/mqtt_agent/: mqtt_agent_task.c mqtt_agent_task.h
    ../../../../../../Source/Library/Web/AWSIoTClient/aws_iot/iot-reference/examples/common/shadow_tasks/: shadow_device_task.c shadow_update_task.c
  group Source/Library/Web/AWSIoTClient/aws_iot/iot-reference/mqtt-agent-interface
    ../../../../../../Source/Library/Web/AWSIoTClient/aws_iot/iot-reference/mqtt-agent-interface/: freertos_agent_message.c freertos_command_pool.c
    ../../../../../../Source/Library/Web/AWSIoTClient/aws_iot/iot-reference/mqtt-agent-interface/include/: freertos_agent_message.h freertos_command_pool.h
  group Source/Library/Web/AWSIoTClient/mflash
    ../../../../../../Source/Library/Web/AWSIoTClient/mflash/: mflash_common.h mflash_drv.c mflash_drv.h mflash_file.c mflash_file.h
  group Source/Library/Web/BasicWeb
    ../../../../../../Source/Library/Web/BasicWeb/: BasicWEB.c BasicWEB.h
  group Source/Library/Web/HTTPServer
    ../../../../../../Source/Library/Web/HTTPServer/: HTTPServer.c HTTPServer.h
  group Source/Platform/emWin
    ../../../../../../Source/Platform/emWin/: GUI_X_uEZ.c
  group Source/Platform/emWin/Config
    ../../../../../../Source/Platform/emWin/Config/: GUIConf.c GUIConf.h LCDConf.c LCDConf.h
  group Source/Processor/ARM/CMSIS
    ../../../../../../Source/Processor/ARM/CMSIS/Include/: cmsis_armclang.h cmsis_clang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_ca.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm52.h core_cm55.h core_cm7.h core_cm85.h core_sc000.h core_sc300.h core_starmc1.h core_starmc3.h tz_context.h
  group Source/Processor/ARM/CMSIS/m-profile
    ../../../../../../Source/Processor/ARM/CMSIS/Include/m-profile/: armv7m_cachel1.h armv7m_mpu.h armv81m_pac.h armv8m_mpu.h armv8m_pmu.h cmsis_armclang_m.h cmsis_clang_m.h cmsis_gcc_m.h cmsis_iccarm_m.h cmsis_tiarmclang_m.h
  group Source/Processor/ARM/DSP
    ../../../../../../Source/Processor/ARM/DSP/ComputeLibrary/Source/: arm_cl_tables.c
    ../../../../../../Source/Processor/ARM/DSP/Include/: arm_common_tables.h arm_common_tables_f16.h arm_const_structs.h arm_const_structs_f16.h arm_helium_utils.h arm_math.h arm_math_f16.h arm_math_memory.h arm_math_types.h arm_math_types_f16.h arm_mve_tables.h arm_mve_tables_f16.h arm_vec_math.h arm_vec_math_f16.h
    ../../../../../../Source/Processor/ARM/DSP/ComputeLibrary/Include/: NEMath.h
  group Source/Processor/ARM/DSP/dsp_inc
    ../../../../../../Source/Processor/ARM/DSP/PrivateInclude/: arm_sorting.h arm_vec_fft.h arm_vec_filtering.h
    ../../../../../../Source/Processor/ARM/DSP/Include/dsp/: basic_math_functions.h basic_math_functions_f16.h bayes_functions.h bayes_functions_f16.h complex_math_functions.h complex_math_functions_f16.h controller_functions.h controller_functions_f16.h debug.h distance_functions.h distance_functions_f16.h fast_math_functions.h fast_math_functions_f16.h filtering_functions.h filtering_functions_f16.h interpolation_functions.h interpolation_functions_f16.h matrix_functions.h matrix_functions_f16.h matrix_utils.h none.h quaternion_math_functions.h statistics_functions.h statistics_functions_f16.h support_functions.h support_functions_f16.h svm_defines.h svm_functions.h svm_functions_f16.h transform_functions.h transform_functions_f16.h utils.h window_functions.h
  group Source/Processor/ARM/DSP/dsp_src
    ../../../../../../Source/Processor/ARM/DSP/Source/BasicMathFunctions/: arm_abs_f16.c arm_abs_f32.c arm_abs_f64.c arm_abs_q15.c arm_abs_q31.c arm_abs_q7.c arm_add_f16.c arm_add_f32.c arm_add_f64.c arm_add_q15.c arm_add_q31.c arm_add_q7.c arm_and_u16.c arm_and_u32.c arm_and_u8.c arm_clip_f16.c arm_clip_f32.c arm_clip_q15.c arm_clip_q31.c arm_clip_q7.c arm_dot_prod_f16.c arm_dot_prod_f32.c arm_dot_prod_f64.c arm_dot_prod_q15.c arm_dot_prod_q31.c arm_dot_prod_q7.c arm_mult_f16.c arm_mult_f32.c arm_mult_f64.c arm_mult_q15.c arm_mult_q31.c arm_mult_q7.c arm_negate_f16.c arm_negate_f32.c arm_negate_f64.c arm_negate_q15.c arm_negate_q31.c arm_negate_q7.c arm_not_u16.c arm_not_u32.c arm_not_u8.c arm_offset_f16.c arm_offset_f32.c arm_offset_f64.c arm_offset_q15.c arm_offset_q31.c arm_offset_q7.c arm_or_u16.c arm_or_u32.c arm_or_u8.c arm_scale_f16.c arm_scale_f32.c arm_scale_f64.c arm_scale_q15.c arm_scale_q31.c arm_scale_q7.c arm_shift_q15.c arm_shift_q31.c arm_shift_q7.c arm_sub_f16.c arm_sub_f32.c arm_sub_f64.c arm_sub_q15.c arm_sub_q31.c arm_sub_q7.c arm_xor_u16.c arm_xor_u32.c arm_xor_u8.c BasicMathFunctions.c BasicMathFunctionsF16.c
    ../../../../../../Source/Processor/ARM/DSP/Source/StatisticsFunctions/: arm_absmax_f16.c arm_absmax_f32.c arm_absmax_f64.c arm_absmax_no_idx_f16.c arm_absmax_no_idx_f32.c arm_absmax_no_idx_f64.c arm_absmax_no_idx_q15.c arm_absmax_no_idx_q31.c arm_absmax_no_idx_q7.c arm_absmax_q15.c arm_absmax_q31.c arm_absmax_q7.c arm_absmin_f16.c arm_absmin_f32.c arm_absmin_f64.c arm_absmin_no_idx_f16.c arm_absmin_no_idx_f32.c arm_absmin_no_idx_f64.c arm_absmin_no_idx_q15.c arm_absmin_no_idx_q31.c arm_absmin_no_idx_q7.c arm_absmin_q15.c arm_absmin_q31.c arm_absmin_q7.c arm_accumulate_f16.c arm_accumulate_f32.c arm_accumulate_f64.c arm_entropy_f16.c arm_entropy_f32.c arm_entropy_f64.c arm_kullback_leibler_f16.c arm_kullback_leibler_f32.c arm_kullback_leibler_f64.c arm_logsumexp_dot_prod_f16.c arm_logsumexp_dot_prod_f32.c arm_logsumexp_f16.c arm_logsumexp_f32.c arm_max_f16.c arm_max_f32.c arm_max_f64.c arm_max_no_idx_f16.c arm_max_no_idx_f32.c arm_max_no_idx_f64.c arm_max_no_idx_q15.c arm_max_no_idx_q31.c arm_max_no_idx_q7.c arm_max_q15.c arm_max_q31.c arm_max_q7.c arm_mean_f16.c arm_mean_f32.c arm_mean_f64.c arm_mean_q15.c arm_mean_q31.c arm_mean_q7.c arm_min_f16.c arm_min_f32.c arm_min_f64.c arm_min_no_idx_f16.c arm_min_no_idx_f32.c arm_min_no_idx_f64.c arm_min_no_idx_q15.c arm_min_no_idx_q31.c arm_min_no_idx_q7.c arm_min_q15.c arm_min_q31.c arm_min_q7.c arm_mse_f16.c arm_mse_f32.c arm_mse_f64.c arm_mse_q15.c arm_mse_q31.c arm_mse_q7.c arm_power_f16.c arm_power_f32.c arm_power_f64.c arm_power_q15.c arm_power_q31.c arm_power_q7.c arm_rms_f16.c arm_rms_f32.c arm_rms_q15.c arm_rms_q31.c arm_std_f16.c arm_std_f32.c arm_std_f64.c arm_std_q15.c arm_std_q31.c arm_var_f16.c arm_var_f32.c arm_var_f64.c arm_var_q15.c arm_var_q31.c StatisticsFunctions.c StatisticsFunctionsF16.c
    ../../../../../../Source/Processor/ARM/DSP/Source/FastMathFunctions/: arm_atan2_f16.c arm_atan2_f32.c arm_atan2_q15.c arm_atan2_q31.c arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_divide_q15.c arm_divide_q31.c arm_sin_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c arm_vexp_f16.c arm_vexp_f32.c arm_vexp_f64.c arm_vinverse_f16.c arm_vlog_f16.c arm_vlog_f32.c arm_vlog_f64.c arm_vlog_q15.c arm_vlog_q31.c FastMathFunctions.c FastMathFunctionsF16.c
    ../../../../../../Source/Processor/ARM/DSP/Source/WindowFunctions/: arm_bartlett_f32.c arm_bartlett_f64.c arm_blackman_harris_92db_f32.c arm_blackman_harris_92db_f64.c arm_hamming_f32.c arm_hamming_f64.c arm_hanning_f32.c arm_hanning_f64.c arm_hft116d_f32.c arm_hft116d_f64.c arm_hft144d_f32.c arm_hft144d_f64.c arm_hft169d_f32.c arm_hft169d_f64.c arm_hft196d_f32.c arm_hft196d_f64.c arm_hft223d_f32.c arm_hft223d_f64.c arm_hft248d_f32.c arm_hft248d_f64.c arm_hft90d_f32.c arm_hft90d_f64.c arm_hft95_f32.c arm_hft95_f64.c arm_nuttall3_f32.c arm_nuttall3_f64.c arm_nuttall3a_f32.c arm_nuttall3a_f64.c arm_nuttall3b_f32.c arm_nuttall3b_f64.c arm_nuttall4_f32.c arm_nuttall4_f64.c arm_nuttall4a_f32.c arm_nuttall4a_f64.c arm_nuttall4b_f32.c arm_nuttall4b_f64.c arm_nuttall4c_f32.c arm_nuttall4c_f64.c arm_welch_f32.c arm_welch_f64.c WindowFunctions.c
    ../../../../../../Source/Processor/ARM/DSP/Source/SupportFunctions/: arm_barycenter_f16.c arm_barycenter_f32.c arm_bitonic_sort_f32.c arm_bubble_sort_f32.c arm_copy_f16.c arm_copy_f32.c arm_copy_f64.c arm_copy_q15.c arm_copy_q31.c arm_copy_q7.c arm_f16_to_f64.c arm_f16_to_float.c arm_f16_to_q15.c arm_f64_to_f16.c arm_f64_to_float.c arm_f64_to_q15.c arm_f64_to_q31.c arm_f64_to_q7.c arm_fill_f16.c arm_fill_f32.c arm_fill_f64.c arm_fill_q15.c arm_fill_q31.c arm_fill_q7.c arm_float_to_f16.c arm_float_to_f64.c arm_float_to_q15.c arm_float_to_q31.c arm_float_to_q7.c arm_heap_sort_f32.c arm_insertion_sort_f32.c arm_merge_sort_f32.c arm_merge_sort_init_f32.c arm_q15_to_f16.c arm_q15_to_f64.c arm_q15_to_float.c arm_q15_to_q31.c arm_q15_to_q7.c arm_q31_to_f64.c arm_q31_to_float.c arm_q31_to_q15.c arm_q31_to_q7.c arm_q7_to_f64.c arm_q7_to_float.c arm_q7_to_q15.c arm_q7_to_q31.c arm_quick_sort_f32.c arm_selection_sort_f32.c arm_sort_f32.c arm_sort_init_f32.c arm_weighted_average_f16.c arm_weighted_average_f32.c SupportFunctions.c SupportFunctionsF16.c
    ../../../../../../Source/Processor/ARM/DSP/Source/InterpolationFunctions/: arm_bilinear_interp_f16.c arm_bilinear_interp_f32.c arm_bilinear_interp_q15.c arm_bilinear_interp_q31.c arm_bilinear_interp_q7.c arm_linear_interp_f16.c arm_linear_interp_f32.c arm_linear_interp_q15.c arm_linear_interp_q31.c arm_linear_interp_q7.c arm_spline_interp_f32.c arm_spline_interp_init_f32.c InterpolationFunctions.c InterpolationFunctionsF16.c
    ../../../../../../Source/Processor/ARM/DSP/Source/FilteringFunctions/: arm_biquad_cascade_df1_32x64_init_q31.c arm_biquad_cascade_df1_32x64_q31.c arm_biquad_cascade_df1_f16.c arm_biquad_cascade_df1_f32.c arm_biquad_cascade_df1_fast_q15.c arm_biquad_cascade_df1_fast_q31.c arm_biquad_cascade_df1_init_f16.c arm_biquad_cascade_df1_init_f32.c arm_biquad_cascade_df1_init_q15.c arm_biquad_cascade_df1_init_q31.c arm_biquad_cascade_df1_q15.c arm_biquad_cascade_df1_q31.c arm_biquad_cascade_df2T_f16.c arm_biquad_cascade_df2T_f32.c arm_biquad_cascade_df2T_f64.c arm_biquad_cascade_df2T_init_f16.c arm_biquad_cascade_df2T_init_f32.c arm_biquad_cascade_df2T_init_f64.c arm_biquad_cascade_stereo_df2T_f16.c arm_biquad_cascade_stereo_df2T_f32.c arm_biquad_cascade_stereo_df2T_init_f16.c arm_biquad_cascade_stereo_df2T_init_f32.c arm_conv_f32.c arm_conv_fast_opt_q15.c arm_conv_fast_q15.c arm_conv_fast_q31.c arm_conv_opt_q15.c arm_conv_opt_q7.c arm_conv_partial_f32.c arm_conv_partial_fast_opt_q15.c arm_conv_partial_fast_q15.c arm_conv_partial_fast_q31.c arm_conv_partial_opt_q15.c arm_conv_partial_opt_q7.c arm_conv_partial_q15.c arm_conv_partial_q31.c arm_conv_partial_q7.c arm_conv_q15.c arm_conv_q31.c arm_conv_q7.c arm_correlate_f16.c arm_correlate_f32.c arm_correlate_f64.c arm_correlate_fast_opt_q15.c arm_correlate_fast_q15.c arm_correlate_fast_q31.c arm_correlate_opt_q15.c arm_correlate_opt_q7.c arm_correlate_q15.c arm_correlate_q31.c arm_correlate_q7.c arm_fir_decimate_f32.c arm_fir_decimate_f64.c arm_fir_decimate_fast_q15.c arm_fir_decimate_fast_q31.c arm_fir_decimate_init_f32.c arm_fir_decimate_init_f64.c arm_fir_decimate_init_q15.c arm_fir_decimate_init_q31.c arm_fir_decimate_q15.c arm_fir_decimate_q31.c arm_fir_f16.c arm_fir_f32.c arm_fir_f64.c arm_fir_fast_q15.c arm_fir_fast_q31.c arm_fir_init_f16.c arm_fir_init_f32.c arm_fir_init_f64.c arm_fir_init_q15.c arm_fir_init_q31.c arm_fir_init_q7.c arm_fir_interpolate_f32.c arm_fir_interpolate_init_f32.c arm_fir_interpolate_init_q15.c arm_fir_interpolate_init_q31.c arm_fir_interpolate_q15.c arm_fir_interpolate_q31.c arm_fir_lattice_f32.c arm_fir_lattice_init_f32.c arm_fir_lattice_init_q15.c arm_fir_lattice_init_q31.c arm_fir_lattice_q15.c arm_fir_lattice_q31.c arm_fir_q15.c arm_fir_q31.c arm_fir_q7.c arm_fir_sparse_f32.c arm_fir_sparse_init_f32.c arm_fir_sparse_init_q15.c arm_fir_sparse_init_q31.c arm_fir_sparse_init_q7.c arm_fir_sparse_q15.c arm_fir_sparse_q31.c arm_fir_sparse_q7.c arm_iir_lattice_f32.c arm_iir_lattice_init_f32.c arm_iir_lattice_init_q15.c arm_iir_lattice_init_q31.c arm_iir_lattice_q15.c arm_iir_lattice_q31.c arm_levinson_durbin_f16.c arm_levinson_durbin_f32.c arm_levinson_durbin_q31.c arm_lms_f32.c arm_lms_init_f32.c arm_lms_init_q15.c arm_lms_init_q31.c arm_lms_norm_f32.c arm_lms_norm_init_f32.c arm_lms_norm_init_q15.c arm_lms_norm_init_q31.c arm_lms_norm_q15.c arm_lms_norm_q31.c arm_lms_q15.c arm_lms_q31.c FilteringFunctions.c FilteringFunctionsF16.c
    ../../../../../../Source/Processor/ARM/DSP/Source/TransformFunctions/: arm_bitreversal.c arm_bitreversal2.c arm_bitreversal_f16.c arm_cfft_f16.c arm_cfft_f32.c arm_cfft_f64.c arm_cfft_init_f16.c arm_cfft_init_f32.c arm_cfft_init_f64.c arm_cfft_init_q15.c arm_cfft_init_q31.c arm_cfft_q15.c arm_cfft_q31.c arm_cfft_radix2_f16.c arm_cfft_radix2_f32.c arm_cfft_radix2_init_f16.c arm_cfft_radix2_init_f32.c arm_cfft_radix2_init_q15.c arm_cfft_radix2_init_q31.c arm_cfft_radix2_q15.c arm_cfft_radix2_q31.c arm_cfft_radix4_f16.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f16.c arm_cfft_radix4_init_f32.c arm_cfft_radix4_init_q15.c arm_cfft_radix4_init_q31.c arm_cfft_radix4_q15.c arm_cfft_radix4_q31.c arm_cfft_radix8_f16.c arm_cfft_radix8_f32.c arm_dct4_f32.c arm_dct4_init_f32.c arm_dct4_init_q15.c arm_dct4_init_q31.c arm_dct4_q15.c arm_dct4_q31.c arm_mfcc_f16.c arm_mfcc_f32.c arm_mfcc_init_f16.c arm_mfcc_init_f32.c arm_mfcc_init_q15.c arm_mfcc_init_q31.c arm_mfcc_q15.c arm_mfcc_q31.c arm_rfft_f32.c arm_rfft_fast_f16.c arm_rfft_fast_f32.c arm_rfft_fast_f64.c arm_rfft_fast_init_f16.c arm_rfft_fast_init_f32.c arm_rfft_fast_init_f64.c arm_rfft_init_f32.c arm_rfft_init_q15.c arm_rfft_init_q31.c arm_rfft_q15.c arm_rfft_q31.c TransformFunctions.c TransformFunctionsF16.c
    ../../../../../../Source/Processor/ARM/DSP/Source/DistanceFunctions/: arm_boolean_distance.c arm_braycurtis_distance_f16.c arm_braycurtis_distance_f32.c arm_canberra_distance_f16.c arm_canberra_distance_f32.c arm_chebyshev_distance_f16.c arm_chebyshev_distance_f32.c arm_chebyshev_distance_f64.c arm_cityblock_distance_f16.c arm_cityblock_distance_f32.c arm_cityblock_distance_f64.c arm_correlation_distance_f16.c arm_correlation_distance_f32.c arm_cosine_distance_f16.c arm_cosine_distance_f32.c arm_cosine_distance_f64.c arm_dice_distance.c arm_dtw_distance_f32.c arm_dtw_init_window_q7.c arm_dtw_path_f32.c arm_euclidean_distance_f16.c arm_euclidean_distance_f32.c arm_euclidean_distance_f64.c arm_hamming_distance.c arm_jaccard_distance.c arm_jensenshannon_distance_f16.c arm_jensenshannon_distance_f32.c arm_kulsinski_distance.c arm_minkowski_distance_f16.c arm_minkowski_distance_f32.c arm_rogerstanimoto_distance.c arm_russellrao_distance.c arm_sokalmichener_distance.c arm_sokalsneath_distance.c arm_yule_distance.c DistanceFunctions.c DistanceFunctionsF16.c
    ../../../../../../Source/Processor/ARM/DSP/Source/ComplexMathFunctions/: arm_cmplx_conj_f16.c arm_cmplx_conj_f32.c arm_cmplx_conj_q15.c arm_cmplx_conj_q31.c arm_cmplx_dot_prod_f16.c arm_cmplx_dot_prod_f32.c arm_cmplx_dot_prod_q15.c arm_cmplx_dot_prod_q31.c arm_cmplx_mag_f16.c arm_cmplx_mag_f32.c arm_cmplx_mag_f64.c arm_cmplx_mag_fast_q15.c arm_cmplx_mag_q15.c arm_cmplx_mag_q31.c arm_cmplx_mag_squared_f16.c arm_cmplx_mag_squared_f32.c arm_cmplx_mag_squared_f64.c arm_cmplx_mag_squared_q15.c arm_cmplx_mag_squared_q31.c arm_cmplx_mult_cmplx_f16.c arm_cmplx_mult_cmplx_f32.c arm_cmplx_mult_cmplx_f64.c arm_cmplx_mult_cmplx_q15.c arm_cmplx_mult_cmplx_q31.c arm_cmplx_mult_real_f16.c arm_cmplx_mult_real_f32.c arm_cmplx_mult_real_q15.c arm_cmplx_mult_real_q31.c ComplexMathFunctions.c ComplexMathFunctionsF16.c
    ../../../../../../Source/Processor/ARM/DSP/Source/CommonTables/: arm_common_tables.c arm_common_tables_f16.c arm_const_structs.c arm_const_structs_f16.c arm_mve_tables.c arm_mve_tables_f16.c CommonTables.c CommonTablesF16.c
    ../../../../../../Source/Processor/ARM/DSP/Source/BayesFunctions/: arm_gaussian_naive_bayes_predict_f16.c arm_gaussian_naive_bayes_predict_f32.c BayesFunctions.c BayesFunctionsF16.c
    ../../../../../../Source/Processor/ARM/DSP/Source/MatrixFunctions/: arm_householder_f16.c arm_householder_f32.c arm_householder_f64.c arm_mat_add_f16.c arm_mat_add_f32.c arm_mat_add_q15.c arm_mat_add_q31.c arm_mat_cholesky_f16.c arm_mat_cholesky_f32.c arm_mat_cholesky_f64.c arm_mat_cmplx_mult_f16.c arm_mat_cmplx_mult_f32.c arm_mat_cmplx_mult_q15.c arm_mat_cmplx_mult_q31.c arm_mat_cmplx_trans_f16.c arm_mat_cmplx_trans_f32.c arm_mat_cmplx_trans_q15.c arm_mat_cmplx_trans_q31.c arm_mat_init_f16.c arm_mat_init_f32.c arm_mat_init_f64.c arm_mat_init_q15.c arm_mat_init_q31.c arm_mat_inverse_f16.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_ldlt_f32.c arm_mat_ldlt_f64.c arm_mat_mult_f16.c arm_mat_mult_f32.c arm_mat_mult_f64.c arm_mat_mult_fast_q15.c arm_mat_mult_fast_q31.c arm_mat_mult_opt_q31.c arm_mat_mult_q15.c arm_mat_mult_q31.c arm_mat_mult_q7.c arm_mat_qr_f16.c arm_mat_qr_f32.c arm_mat_qr_f64.c arm_mat_scale_f16.c arm_mat_scale_f32.c arm_mat_scale_q15.c arm_mat_scale_q31.c arm_mat_solve_lower_triangular_f16.c arm_mat_solve_lower_triangular_f32.c arm_mat_solve_lower_triangular_f64.c arm_mat_solve_upper_triangular_f16.c arm_mat_solve_upper_triangular_f32.c arm_mat_solve_upper_triangular_f64.c arm_mat_sub_f16.c arm_mat_sub_f32.c arm_mat_sub_f64.c arm_mat_sub_q15.c arm_mat_sub_q31.c arm_mat_trans_f16.c arm_mat_trans_f32.c arm_mat_trans_f64.c arm_mat_trans_q15.c arm_mat_trans_q31.c arm_mat_trans_q7.c arm_mat_vec_mult_f16.c arm_mat_vec_mult_f32.c arm_mat_vec_mult_q15.c arm_mat_vec_mult_q31.c arm_mat_vec_mult_q7.c MatrixFunctions.c MatrixFunctionsF16.c
    ../../../../../../Source/Processor/ARM/DSP/Source/ControllerFunctions/: arm_pid_init_f32.c arm_pid_init_q15.c arm_pid_init_q31.c arm_pid_reset_f32.c arm_pid_reset_q15.c arm_pid_reset_q31.c arm_sin_cos_f32.c arm_sin_cos_q31.c ControllerFunctions.c
    ../../../../../../Source/Processor/ARM/DSP/Source/QuaternionMathFunctions/: arm_quaternion2rotation_f32.c arm_quaternion_conjugate_f32.c arm_quaternion_inverse_f32.c arm_quaternion_norm_f32.c arm_quaternion_normalize_f32.c arm_quaternion_product_f32.c arm_quaternion_product_single_f32.c arm_rotation2quaternion_f32.c QuaternionMathFunctions.c
    ../../../../../../Source/Processor/ARM/DSP/Source/SVMFunctions/: arm_svm_linear_init_f16.c arm_svm_linear_init_f32.c arm_svm_linear_predict_f16.c arm_svm_linear_predict_f32.c arm_svm_polynomial_init_f16.c arm_svm_polynomial_init_f32.c arm_svm_polynomial_predict_f16.c arm_svm_polynomial_predict_f32.c arm_svm_rbf_init_f16.c arm_svm_rbf_init_f32.c arm_svm_rbf_predict_f16.c arm_svm_rbf_predict_f32.c arm_svm_sigmoid_init_f16.c arm_svm_sigmoid_init_f32.c arm_svm_sigmoid_predict_f16.c arm_svm_sigmoid_predict_f32.c SVMFunctions.c SVMFunctionsF16.c
  group Source/Processor/NXP/LPC17xx_40xx
    ../../../../../../Source/Processor/NXP/LPC17xx_40xx/: Config_Processor.h LPC17xx_40xx_ADCBank.c LPC17xx_40xx_ADCBank.h LPC17xx_40xx_BatteryRAM.c LPC17xx_40xx_BatteryRAM.h LPC17xx_40xx_CAN.c LPC17xx_40xx_CAN.h LPC17xx_40xx_CRC.c LPC17xx_40xx_CRC.h LPC17xx_40xx_DAC.c LPC17xx_40xx_DAC.h LPC17xx_40xx_EINT.c LPC17xx_40xx_EINT.h LPC17xx_40xx_EMAC.c LPC17xx_40xx_EMAC.h LPC17xx_40xx_EMC_Static.c LPC17xx_40xx_EMC_Static.h LPC17xx_40xx_ExternalBus.c LPC17xx_40xx_ExternalBus.h LPC17xx_40xx_GPDMA.c LPC17xx_40xx_GPDMA.h LPC17xx_40xx_GPIO.c LPC17xx_40xx_GPIO.h LPC17xx_40xx_HALInit.c LPC17xx_40xx_I2C.c LPC17xx_40xx_I2C.h LPC17xx_40xx_I2S.c LPC17xx_40xx_I2S.h LPC17xx_40xx_Interrupt.c LPC17xx_40xx_LCDController.c LPC17xx_40xx_LCDController.h LPC17xx_40xx_MCI.c LPC17xx_40xx_PLL.c LPC17xx_40xx_PLL.h LPC17xx_40xx_PWM.c LPC17xx_40xx_PWM.h LPC17xx_40xx_RTC.c LPC17xx_40xx_RTC.h LPC17xx_40xx_SDRAM.c LPC17xx_40xx_SDRAM.h LPC17xx_40xx_Serial.c LPC17xx_40xx_Serial.h LPC17xx_40xx_SSP.c LPC17xx_40xx_SSP.h LPC17xx_40xx_Timer.c LPC17xx_40xx_Timer.h LPC17xx_40xx_USBDeviceController.c LPC17xx_40xx_USBDeviceController.h LPC17xx_40xx_USBHost.c LPC17xx_40xx_USBSharedInterrupt.c LPC17xx_40xx_UtilityFuncs.c LPC17xx_40xx_UtilityFuncs.h LPC17xx_40xx_Watchdog.c LPC17xx_40xx_Watchdog.h uEZProcessor_LPC17xx_40xx.h
  group Source/Processor/NXP/LPC17xx_40xx/include
    ../../../../../../Source/Processor/NXP/LPC17xx_40xx/Common/include/: LPC407x_8x_177x_8x.h system_LPC407x_8x_177x_8x.c system_LPC407x_8x_177x_8x.h
  group Source/Processor/NXP/LPC17xx_40xx/IAR
    ../../../../../../Source/Processor/NXP/LPC17xx_40xx/IAR/: LPC17xx40xx_Startup.s
  group Source/RTOS
    ../../../../../../Source/RTOS/: uEZRTOS.c
  group Source/RTOS/FreeRTOS
    ../../../../../../Source/RTOS/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Source/RTOS/FreeRTOS/include
    ../../../../../../Source/RTOS/FreeRTOS/include/: atomic.h croutine.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
  group Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F
    ../../../../../../Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group Source/RTOS/FreeRTOS/portable/MemMang
    ../../../../../../Source/RTOS/FreeRTOS/portable/MemMang/: heap_1.c heap_2.c heap_3.c heap_4.c heap_5.c
  group Source/RTOS/FreeRTOS-Plus/Application-Protocols/coreHTTP
    ../../../../../../Source/RTOS/FreeRTOS-Plus/Application-Protocols/coreHTTP/source/: core_http_client.c
    ../../../../../../Source/RTOS/FreeRTOS-Plus/Application-Protocols/coreHTTP/source/include/: core_http_client.h core_http_client_private.h core_http_config_defaults.h
    ../../../../../../Source/RTOS/FreeRTOS-Plus/Application-Protocols/coreHTTP/source/interface/: transport_interface.h
  group Source/RTOS/FreeRTOS-Plus/Application-Protocols/coreMQTT
    ../../../../../../Source/RTOS/FreeRTOS-Plus/Application-Protocols/coreMQTT/source/: core_mqtt.c core_mqtt_serializer.c core_mqtt_state.c
    ../../../../../../Source/RTOS/FreeRTOS-Plus/Application-Protocols/coreMQTT/source/include/: core_mqtt.h core_mqtt_config_defaults.h core_mqtt_default_logging.h core_mqtt_serializer.h core_mqtt_state.h
    ../../../../../../Source/RTOS/FreeRTOS-Plus/Application-Protocols/coreMQTT/source/interface/: transport_interface.h
  group Source/RTOS/FreeRTOS-Plus/Application-Protocols/coreMQTT-Agent
    ../../../../../../Source/RTOS/FreeRTOS-Plus/Application-Protocols/coreMQTT-Agent/source/: core_mqtt_agent.c core_mqtt_agent_command_functions.c
    ../../../../../../Source/RTOS/FreeRTOS-Plus/Application-Protocols/coreMQTT-Agent/source/include/: core_mqtt_agent.h core_mqtt_agent_command_functions.h core_mqtt_agent_config_defaults.h core_mqtt_agent_default_logging.h core_mqtt_agent_message_interface.h
  group Source/RTOS/FreeRTOS-Plus/Application-Protocols/coreSNTP
    ../../../../../../Source/RTOS/FreeRTOS-Plus/Application-Protocols/coreSNTP/source/: core_sntp_client.c core_sntp_serializer.c
    ../../../../../../Source/RTOS/FreeRTOS-Plus/Application-Protocols/coreSNTP/source/include/: core_sntp_client.h core_sntp_config_defaults.h core_sntp_serializer.h
  group Source/RTOS/FreeRTOS-Plus/Application-Protocols/network_transport
    ../../../../../../Source/RTOS/FreeRTOS-Plus/Application-Protocols/network_transport/: mbedtls_bio_tcp_sockets_wrapper.c mbedtls_bio_tcp_sockets_wrapper.h mbedtls_pk_pkcs11.c mbedtls_pkcs11.h mbedtls_rng_pkcs11.c transport_mbedtls.h transport_mbedtls_pkcs11.h transport_plaintext.h transport_wolfSSL.h
    ../../../../../../Source/RTOS/FreeRTOS-Plus/Application-Protocols/network_transport/tcp_sockets_wrapper/ports/freertos_plus_tcp/: sockets_wrapper.c sockets_wrapper.h tcp_sockets_wrapper.c
    ../../../../../../Source/RTOS/FreeRTOS-Plus/Application-Protocols/network_transport/tcp_sockets_wrapper/include/: tcp_sockets_wrapper.h
  group Source/RTOS/FreeRTOS-Plus/AWS/device-defender
    ../../../../../../Source/RTOS/FreeRTOS-Plus/AWS/device-defender/source/: defender.c
    ../../../../../../Source/RTOS/FreeRTOS-Plus/AWS/device-defender/source/include/: defender.h defender_config_defaults.h
  group Source/RTOS/FreeRTOS-Plus/AWS/device-shadow
    ../../../../../../Source/RTOS/FreeRTOS-Plus/AWS/device-shadow/source/: shadow.c
    ../../../../../../Source/RTOS/FreeRTOS-Plus/AWS/device-shadow/source/include/: shadow.h shadow_config_defaults.h
  group Source/RTOS/FreeRTOS-Plus/backoffAlgorithm
    ../../../../../../Source/RTOS/FreeRTOS-Plus/backoffAlgorithm/source/: backoff_algorithm.c
    ../../../../../../Source/RTOS/FreeRTOS-Plus/backoffAlgorithm/source/include/: backoff_algorithm.h
  group Source/RTOS/FreeRTOS-Plus/coreJSON
    ../../../../../../Source/RTOS/FreeRTOS-Plus/coreJSON/source/: core_json.c
    ../../../../../../Source/RTOS/FreeRTOS-Plus/coreJSON/source/include/: core_json.h
  group Source/RTOS/FreeRTOS-Plus/corePKCS11
    ../../../../../../Source/RTOS/FreeRTOS-Plus/corePKCS11/source/: core_pkcs11.c core_pki_utils.c
    ../../../../../../Source/RTOS/FreeRTOS-Plus/corePKCS11/source/include/: core_pkcs11.h core_pkcs11_config_defaults.h core_pkcs11_pal.h core_pki_utils.h
    ../../../../../../Source/RTOS/FreeRTOS-Plus/corePKCS11/source/portable/mbedtls/: core_pkcs11_mbedtls.c
    ../../../../../../Source/RTOS/FreeRTOS-Plus/corePKCS11/source/portable/os/: core_pkcs11_pal_utils.c core_pkcs11_pal_utils.h
    ../../../../../../Source/RTOS/FreeRTOS-Plus/corePKCS11/source/dependency/3rdparty/mbedtls_utils/: mbedtls_utils.c mbedtls_utils.h
    ../../../../../../Source/RTOS/FreeRTOS-Plus/corePKCS11/source/dependency/3rdparty/pkcs11/: pkcs11.h pkcs11f.h pkcs11t.h
  group Source/RTOS/FreeRTOS-Plus/FreeRTOS-Plus-TCP
    ../../../../../../Source/RTOS/FreeRTOS-Plus/FreeRTOS-Plus-TCP/source/: FreeRTOS_ARP.c FreeRTOS_BitConfig.c FreeRTOS_DHCP.c FreeRTOS_DHCPv6.c FreeRTOS_DNS.c FreeRTOS_DNS_Cache.c FreeRTOS_DNS_Callback.c FreeRTOS_DNS_Networking.c FreeRTOS_DNS_Parser.c FreeRTOS_ICMP.c FreeRTOS_IP.c FreeRTOS_IP_Timers.c FreeRTOS_IP_Utils.c FreeRTOS_IPv4.c FreeRTOS_IPv4_Sockets.c FreeRTOS_IPv4_Utils.c FreeRTOS_IPv6.c FreeRTOS_IPv6_Sockets.c FreeRTOS_IPv6_Utils.c FreeRTOS_ND.c FreeRTOS_RA.c FreeRTOS_Routing.c FreeRTOS_Sockets.c FreeRTOS_Stream_Buffer.c FreeRTOS_TCP_IP.c FreeRTOS_TCP_IP_IPv4.c FreeRTOS_TCP_IP_IPv6.c FreeRTOS_TCP_Reception.c FreeRTOS_TCP_State_Handling.c FreeRTOS_TCP_State_Handling_IPv4.c FreeRTOS_TCP_State_Handling_IPv6.c FreeRTOS_TCP_Transmission.c FreeRTOS_TCP_Transmission_IPv4.c FreeRTOS_TCP_Transmission_IPv6.c FreeRTOS_TCP_Utils.c FreeRTOS_TCP_Utils_IPv4.c FreeRTOS_TCP_Utils_IPv6.c FreeRTOS_TCP_WIN.c FreeRTOS_Tiny_TCP.c FreeRTOS_UDP_IP.c FreeRTOS_UDP_IPv4.c FreeRTOS_UDP_IPv6.c
  group Source/RTOS/FreeRTOS-Plus/FreeRTOS-Plus-TCP/include
    ../../../../../../Source/RTOS/FreeRTOS-Plus/FreeRTOS-Plus-TCP/source/include/: FreeRTOS_ARP.h FreeRTOS_BitConfig.h FreeRTOS_DHCP.h FreeRTOS_DHCPv6.h FreeRTOS_DNS.h FreeRTOS_DNS_Cache.h FreeRTOS_DNS_Callback.h FreeRTOS_DNS_Globals.h FreeRTOS_DNS_Networking.h FreeRTOS_DNS_Parser.h FreeRTOS_errno_TCP.h FreeRTOS_ICMP.h FreeRTOS_IP.h FreeRTOS_IP_Common.h FreeRTOS_IP_Private.h FreeRTOS_IP_Timers.h FreeRTOS_IP_Utils.h FreeRTOS_IPv4.h FreeRTOS_IPv4_Private.h FreeRTOS_IPv4_Sockets.h FreeRTOS_IPv4_Utils.h FreeRTOS_IPv6.h FreeRTOS_IPv6_Private.h FreeRTOS_IPv6_Sockets.h FreeRTOS_IPv6_Utils.h FreeRTOS_ND.h FreeRTOS_Routing.h FreeRTOS_Sockets.h FreeRTOS_Stream_Buffer.h FreeRTOS_TCP_IP.h FreeRTOS_TCP_Reception.h FreeRTOS_TCP_State_Handling.h FreeRTOS_TCP_Transmission.h FreeRTOS_TCP_Utils.h FreeRTOS_TCP_WIN.h FreeRTOS_UDP_IP.h FreeRTOSIPConfigDefaults.h IPTraceMacroDefaults.h NetworkBufferManagement.h NetworkInterface.h
  group Source/RTOS/FreeRTOS-Plus/FreeRTOS-Plus-TCP/portable
    ../../../../../../Source/RTOS/FreeRTOS-Plus/FreeRTOS-Plus-TCP/source/portable/BufferManagement/: BufferAllocation_1.c BufferAllocation_2.c
  group Source/RTOS/FreeRTOS-Plus/Utilities/logging
    ../../../../../../Source/RTOS/FreeRTOS-Plus/Utilities/logging/: logging.h logging_levels.h logging_stack.h
  group Source/uEZSystem
    ../../../../../../Source/uEZSystem/: HAL.c uEZAccelerometer.c uEZADC.c uEZAudioAmp.c uEZAudioMixer.c uEZBSPInit.c uEZButton.c uEZCAN.c uEZCharDisplay.c uEZCRC.c uEZDAC.c uEZDeviceTable.c uEZEEPROM.c uEZEINT.c uEZFile.c uEZFlash.c uEZGPIO.c uEZHandles.c uEZHandles.h uEZHID.c uEZI2C.c uEZINI.c uEZInit.c uEZKeypad.c uEZLCD.c uEZLEDBank.c uEZMemory.c uEZNetwork.c uEZPWM.c uEZRandom.c uEZResourceCache.c uEZSPI.c uEZStream.c uEZTemperature.c uEZTimeDate.c uEZTimer.c uEZToneGenerator.c uEZTS.c uEZWatchdog.c uEZWAVFile.c
