<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\uEZ_NXP_LPC1768_FreeRTOS_IAR.ewp</path>
  </project>
  <batchBuild/>
</workspace>


