# Keil uVision project uEZ_NXP_LPC4357_FreeRTOS_KEIL.uvprojx, settings and files
target Debug (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC4357:Cortex-M4 NXP
  pack: Keil.LPC4300_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uEZ_NXP_LPC4357_FreeRTOS_Keil_Debug +hex (library)
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=1
  c define: COMPILER_TYPE=Keil4, GCC_ARMCM4F, DEBUG
  c include: .;..\..\..\..\..\..;..\..\..\..\..\..\Include;..\..\..\..\..\..\Source\Library\lwIP;..\..\..\..\..\..\Source\Library\lwIP\Include;..\..\..\..\..\..\Source\Library\lwIP\src\include;..\..\..\..\..\..\Source\Library\lwIP\src;..\..\..\..\..\..\Source\Library\lwIP\src\include\ipv4;..\..\..\..\..\..\Source\RTOS\FreeRTOS\include;..\..\..\..\..\..\Source\Processor\NXP\LPC43xx;..\..\..\..\..\..\Source\Processor\NXP\LPC43xx\Keil;..\..\..\..\..\..\Source\Processor\NXP\LPC43xx\Keil\include;..\..\..\..\..\..\Source\Processor\NXP\LPC43xx\Keil\include\CMSIS;..\..\..\..\..\..\Source\Library\GUI\SEGGER\emWin;..\..\..\..\..\..\Source\Platform\emWin\Config;..\..\..\..\..\..\Source\Platform\emWin\Inc;..\..\..\..\..\..\Source\Library\Encryption\CyaSSL;..\..\..\..\..\..\Source\Library\Encryption\CyaSSL\cyassl;..\..\..\..\..\..\Source\Library\Encryption\CyaSSL\cyassl\ctaocrypt;..\..\..\..\..\..\Source\Library\Encryption\CyaSSL\cyassl\openssl;..\..\..\..\..\..\Source\RTOS\FreeRTOS\FreeRTOS-Plus-Trace\Include;..\..\..\..\..\..\Source\Library\LPCOpen
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: --verbose --entry=UEZBSPInit
  group Build
    ./: Config_Build.h
  group Devices/Accelerometer/Analog Devices/ADXL345
    ../../../../../../Source/Devices/Accelerometer/Analog Devices/ADXL345/: Accelerometer_ADXL345.c
  group Devices/Accelerometer/Bosch/BMA150
    ../../../../../../Source/Devices/Accelerometer/Bosch/BMA150/: Bosch_BMA150_I2C_driver.c
  group Devices/Accelerometer/Freescale/MMA7455
    ../../../../../../Source/Devices/Accelerometer/Freescale/MMA7455/: Freescale_MMA7455_driver.c
  group Devices/Accelerometer/ST/LIS3LV02DQ
    ../../../../../../Source/Devices/Accelerometer/ST/LIS3LV02DQ/: ST_LIS3LV02DQ_I2C_driver.c
  group Devices/ADC/Generic
    ../../../../../../Source/Devices/ADC/Generic/: Generic_adc.c
  group Devices/AudioAmp/NXP/TDA85551_T
    ../../../../../../Source/Devices/AudioAmp/NXP/TDA8551_T/: AudioAmp_8551T.c
  group Devices/Audio Codec/Wolfson/WM8731
    ../../../../../../Source/Devices/Audio Codec/Wolfson/WM8731/: AudioCodec_WM8731.c
  group Devices/Backlight/Generic/BacklightPWMControlled
    ../../../../../../Source/Devices/Backlight/Generic/BacklightPWMControlled/: BacklightPWMControlled.c
  group Devices/Button/Generic/EINT
    ../../../../../../Source/Devices/Button/Generic/EINT/: Button_Generic_EINT.c Button_Generic_EINT.h
  group Devices/Button/NXP/PCA9551
    ../../../../../../Source/Devices/Button/NXP/PCA9551/: Button_NXP_PCA9551_driver.c Button_PCA9551.h
  group Devices/CharDisplay/Generic/Stream
    ../../../../../../Source/Devices/CharDisplay/Generic/Stream/: CharDisplay_Generic_Stream.c CharDisplay_Generic_Stream.h
  group Devices/CharDisplay/Lumex/SO2004D
    ../../../../../../Source/Devices/CharDisplay/Lumex/SO2004D/: Lumex_SO2004DSR.c Lumex_SO2004DSR.h
  group Devices/CRC/Generic
    ../../../../../../Source/Devices/CRC/Generic/: CRC_Generic.c
  group Devices/DAC/Generic
    ../../../../../../Source/Devices/DAC/Generic/: DAC_Generic.c
  group Devices/EEPROM/Generic/I2C
    ../../../../../../Source/Devices/EEPROM/Generic/I2C/: EEPROM_Generic_I2C_driver.c EEPROM16_Generic_I2C_driver.c
  group Devices/EERPOM/NXP/LPC43xx
    ../../../../../../Source/Devices/EEPROM/NXP/LPC43xx/: EEPROM_NXP_LPC43xx.c
  group Devices/ExternalInterrupt/Generic
    ../../../../../../Source/Devices/ExternalInterrupt/Generic/: ExternalInterrupt_Generic.c
  group Devices/Flash/NXP/LPC43xx
    ../../../../../../Source/Devices/Flash/NXP/LPC43xx/: LPC43xx_IAP.c LPC43xx_IAP.h
  group Source/Devices/Flash/NXP/LPC_SPIFI_M4F/
    ../../../../../../Source/Devices/Flash/NXP/LPC_SPIFI_M4F/: Flash_NXP_LPC_SPIFI_M4.h Flash_NXP_LPC_SPIFI_M4_driver.c spifilib_api.h spifilib_chiphw.h spifilib_dev.h spifilib_dev_common.c spifilib_fam_standard_cmd.c
  group Devices/GPDMA/Generic
    ../../../../../../Source/Devices/GPDMA/Generic/: Generic_GPDMA.c
  group Devices/HID/Generic
    ../../../../../../Source/Devices/HID/Generic/: HID_Generic.c
  group Devices/I2C/Generic
    ../../../../../../Source/Devices/I2C/Generic/: Generic_i2c.c
  group Devices/I2S/Generic
    ../../../../../../Source/Devices/I2S/Generic/: Generic_i2s.c
  group Devices/Keypad/NXP/I2C_Keypad
    ../../../../../../Source/Devices/Keypad/NXP/I2C_Keypad/: Keypad_NXP_I2C_PCA9555_driver.c
  group Devices/LCD/DigitalImage/G050720DSSWDG01
    ../../../../../../Source/Devices/LCD/DigitalImage/FG050720DSSWDG01/: LCD_DigitalImage_FG050720DSSWDG01.c
  group Devices/LCD/Hitachi/TX11D06VM2APA
    ../../../../../../Source/Devices/LCD/Hitachi/TX11D06VM2APA/: Hitachi_TX11D06VM2APA.c
  group Devices/LCD/Inteltronic/LMIX0560NTN53V1
    ../../../../../../Source/Devices/LCD/Inteltronic/LMIX0560NTN53V1/: Inteltronic_LMIX0560NTN53V1.c
  group Devices/LCD/OKAYA/RH320240T
    ../../../../../../Source/Devices/LCD/OKAYA/RH320240T/: Okaya_rh320240t.c
  group Devices/LCD/OKAYA/RV320240T
    ../../../../../../Source/Devices/LCD/OKAYA/RV320240T/: Okaya_rv320240t.c
  group Devices/LCD/OKAYA/RV640480T
    ../../../../../../Source/Devices/LCD/OKAYA/RV640480T/: Okaya_RV640480T.c
  group Devices/LCD/Seiko/70WVW2T
    ../../../../../../Source/Devices/LCD/Seiko/70WVW2T/: Seiko_70WVW2T.c
  group Devices/LCD/Sharp/LQ043T1DG01
    ../../../../../../Source/Devices/LCD/Sharp/LQ043T1DG01/: Sharp_LQ043T1DG01.c
  group Devices/LCD/Sharp/LQ043T3DG02
    ../../../../../../Source/Devices/LCD/Sharp/LQ043T3DG02/: Sharp_LQ043T3DG02.c
  group Devices/LCD/Sharp/LQ043T3DG28
    ../../../../../../Source/Devices/LCD/Sharp/LQ043T1DG28/: Sharp_LQ043T1DG28.c
  group Devices/LCD/Tianma/T070RBHG04
    ../../../../../../Source/Devices/LCD/Tianma/TM070RBHG04/: Tianma_TM070RBHG04.c
  group Devices/LCD/Tianma/TM043NBH02
    ../../../../../../Source/Devices/LCD/Tianma/TM043NBH02/: Tianma_TM043NBH02.c
  group Devices/LCD/Tianma/TM047NBH01
    ../../../../../../Source/Devices/LCD/Tianma/TM047NBH01/: Tianma_TM047NBH01.c
  group Devices/LCD/Toshiba/LTA057A347F
    ../../../../../../Source/Devices/LCD/Toshiba/LTA057A347F/: Toshiba_LTA057A347F.c
  group Devices/LED/Generic/GPIO
    ../../../../../../Source/Devices/LED/Generic/GPIO/: LED_Generic_GPIO.c
  group Devices/LED/NXP/PCA9551
    ../../../../../../Source/Devices/LED/NXP/PCA9551/: LED_NXP_PCA9551_driver.c
  group Devices/MassStorage/SDCard
    ../../../../../../Source/Devices/MassStorage/SDCard/: SDCard_MS_driver_SD_MMC.c SDCard_MS_driver_SD_MMC.h
  group Devices/MassStorage/LPCUSBLib
    ../../../../../../Source/Devices/MassStorage/LPCUSBLib/: LPCUSBLib_MS.c LPCUSBLib_MS.h
  group Devices/Network/GainSpan
    ../../../../../../Source/Devices/Network/GainSpan/: Network_GainSpan.c Network_GainSpan.h
  group Devices/Network/lwIP
    ../../../../../../Source/Devices/Network/lwIP/: Network_lwIP.c
  group Devices/PWM/Generic
    ../../../../../../Source/Devices/PWM/Generic/: Generic_PWM.c
  group Devices/ResourceCache/Generic/DirectAccess
    ../../../../../../Source/Devices/ResourceCache/Generic/DirectAccess/: ResourceCache_DirectAccess.c
  group Devices/RTC/Generic
    ../../../../../../Source/Devices/RTC/Generic/: generic_rtc.c
  group Devices/RTC/NXP/PCF2129
    ../../../../../../Source/Devices/RTC/NXP/PCF2129/: RTC_PCF2129.c RTC_PCF2129.h
  group Devices/RTC/NXP/PCF8563
    ../../../../../../Source/Devices/RTC/NXP/PCF8563/: RTC_PCF8563.c
  group Devices/Serial/Generic
    ../../../../../../Source/Devices/Serial/Generic/: uEZSerialGeneric.c uEZSerialGenericHalfDuplex.c
  group Devices/Serial/RS485/Generic
    ../../../../../../Source/Devices/Serial/RS485/Generic/: Generic_RS485.c Generic_RS485_Timer.c
  group Devices/SPI/Generic
    ../../../../../../Source/Devices/SPI/Generic/: Generic_spi.c
  group Devices/Stream/SWO
    ../../../../../../Source/Devices/Stream/SWO/: Stream_SWO_CortexM.c
  group Devices/Temperature/Analog Devices/ADT7420
    ../../../../../../Source/Devices/Temperature/Analog Devices/ADT7420/: Temperature_ADT7420.c
  group Devices/Temperature/NXP/LM75A
    ../../../../../../Source/Devices/Temperature/NXP/LM75A/: Temperature_LM75A_driver.c
  group Devices/Timer/Generic
    ../../../../../../Source/Devices/Timer/Generic/: Timer_Generic.c
  group Devices/ToneGenerator/Generic/PWM
    ../../../../../../Source/Devices/ToneGenerator/Generic/PWM/: ToneGenerator_Generic_PWM_driver.c
  group Devices/ToneGenerator/Generic/Timer
    ../../../../../../Source/Devices/ToneGenerator/Generic/Timer/: ToneGenerator_Generic_Timer_driver.c
  group Devices/Touchscreen/Generic/FourWireTouchResist
    ../../../../../../Source/Devices/Touchscreen/Generic/FourWireTouchResist/: FourWireTouchResist_TS.c
  group Devices/Touchscreen/MicroChip/AR1020
    ../../../../../../Source/Devices/Touchscreen/MicroChip/AR1020/: AR1020ResistiveTouchScreen.c
  group Devices/Touchscreen/TI/TSC2046
    ../../../../../../Source/Devices/Touchscreen/TI/TSC2046/: Touchscreen_TI_TSC2046.c
  group Devices/USBHost/Generic
    ../../../../../../Source/Devices/USBHost/Generic/: Generic_USBHost.c
  group Devices/Watchdog/Generic
    ../../../../../../Source/Devices/Watchdog/Generic/: Watchdog_Generic_driver.c
  group Library/Audio/MIDI
    ../../../../../../Source/Library/Audio/MIDI/: MIDIPlayer.c
  group Library/Console/FDI/FDICmd
    ../../../../../../Source/Library/Console/FDICmd/: FDICmd.c
  group Library/Console/FDI/FDICmd/Commands
    ../../../../../../Source/Library/Console/FDICmd/Commands/: FDICmd_File.c FDICmd_I2C.c FDICmd_File.h FDICmd_I2C.h FDICmd_AudioDAC.c FDICmd_AudioDAC.h FDICmd_WAVPlay.c FDICmd_WAVPlay.h
  group Library/FileSystem/FATFS
    ../../../../../../Source/Library/FileSystem/FATFS/: diskio.c diskio.h ff.c ff.h integer.h rtc.c rtc.h uEZFileSystem_FATFS.c
    ../../../../../../Source/Library/FileSystem/FATFS/option/: unicode.c
  group Library/Graphics/SWIM
    ../../../../../../Source/Library/Graphics/SWIM/: lpc_colors.h lpc_droidsansr14.c lpc_droidsansr14.h lpc_droidsansr76.c lpc_droidsansr76.h lpc_fonts.h lpc_helvr10.c lpc_helvr10.h lpc_rom8x8.c lpc_rom8x8.h lpc_rom8x16.c lpc_rom8x16.h lpc_swim.c lpc_swim.h lpc_swim_font.c lpc_swim_font.h lpc_swim_image.c lpc_swim_image.h lpc_types.h lpc_winfreesystem14x16.c lpc_winfreesystem14x16.h lpc_x5x7.c lpc_x5x7.h lpc_x6x13.c lpc_x6x13.h lpc_winfreesystem14x16_subset.c droidsansr32.c droidsansr32.h lpc_winfreesystem14x16_subset.h lpc_swim_driver.c
  group Library/GUI/FDI/SimpleUI
    ../../../../../../Source/Library/GUI/FDI/SimpleUI/: SimpleUI.h SimpleUI_Choices.c SimpleUI_Choices.h SimpleUI_Drawing.c SimpleUI_Drawing.h SimpleUI_Regions.c SimpleUI_Regions.h SimpleUI_Types.h SimpleUI_UtilityFunctions.c SimpleUI_UtilityFunctions.h SimpleUI_DrawBitmap.h SimpleUI_DrawBitmap.c
  group Library/Language/C
    ../../../../../../Source/Library/Language/C/: itoa.c ltoa.c ultoa.c
  group Library/Memory/MemoryTest
    ../../../../../../Source/Library/Memory/MemoryTest/: MemoryTest.c
  group Library/Network/GainSpan/CmdLib
    ../../../../../../Source/Library/Network/GainSpan/CmdLib/: AtCmdLib.c AtCmdLib.h GainSpan_CmdLib.c GainSpan_CmdLib.h GainSpan_Config.h GainSpan_SPI.c GainSpan_SPI.h
  group Library/Network/PHY/MDIOBitBang
    ../../../../../../Source/Library/Network/PHY/MDIOBitBang/: MDIOBitBang.c MDIOBitBang.h
  group Library/Parser/IntelHexParser
    ../../../../../../Source/Library/Parser/IntelHexParser/: IntelHexParser.c
  group Library/StreamIO/StdInOut
    ../../../../../../Source/Library/StreamIO/StdInOut/: StdInOut.c
    ../../../../../../Source/Library/StreamIO/StdInOut/Keil/: StdInOut_Keil.c
  group Library/USBDevice/MassStorage
    ../../../../../../Source/Library/USBDevice/MassStorage/Generic/: USBMSDrive.h USBMSDrive.c
  group Library/uEZFailure
    ../../../../../../Source/Library/uEZFailure/: FatalError.c uEZFailure.c
  group Library/Web/BasicWEB
    ../../../../../../Source/Library/Web/BasicWeb/: BasicWEB.c
  group Library/Web/HTTPServer
    ../../../../../../Source/Library/Web/HTTPServer/: HTTPServer.c HTTPServer.h
  group Platform/emWin
    ../../../../../../Source/Platform/emWin/: GUI_X_uEZ.c
  group Platform/emWin/Config
    ../../../../../../Source/Platform/emWin/Config/: GUIConf.c GUIConf.h LCDConf.c LCDConf.h
  group Platform/emWin/Inc
    ../../../../../../Source/Platform/emWin/Inc/: SEGGER.h
  group Processor/NXP/LPC43xx/Keil
    ../../../../../../Source/Processor/NXP/LPC43xx/Keil/: startup_LPC43xx.s
  group uEZSystem
    ../../../../../../Source/uEZSystem/: HAL.c uEZAccelerometer.c uEZADC.c uEZAudioAmp.c uEZBSPInit.c uEZButton.c uEZCharDisplay.c uEZDAC.c uEZDeviceTable.c uEZEINT.c uEZFile.c uEZFlash.c uEZGPIO.c uEZHandles.c uEZHandles.h uEZHID.c uEZI2C.c uEZINI.c uEZInit.c uEZKeypad.c uEZLCD.c uEZLEDBank.c uEZMemory.c uEZNetwork.c uEZPWM.c uEZRandom.c uEZResourceCache.c uEZSPI.c uEZStream.c uEZTemperature.c uEZTimeDate.c uEZTimer.c uEZToneGenerator.c uEZTS.c uEZWatchdog.c uEZWAVFile.c uEZEEPROM.c uEZAudioMixer.c
  group Library/ScreenSaver
    ../../../../../../Source/Library/ScreenSaver/: BouncingLogoSS.c
  group Library/Audio/DAC
    ../../../../../../Source/Library/Audio/DAC/: UEZDACWavFile.c
  group Device/GPIO/I2C/PCF8574T
    ../../../../../../Source/Devices/GPIO/I2C/PCF8574T/: GPIO_PCF8574T.c GPIO_PCF8574T.h
  group Source\Devices\Keypad\GPIO
    ../../../../../../Source/Devices/Keypad/GPIO/: Keypad_Generic_GPIO.c Keypad_Generic_GPIO.h
  group Device/AudioAmp/TI/LM48100
    ../../../../../../Source/Devices/AudioAmp/TI/LM48100/: AudioAmp_LM48100.c
  group Device/LCD/Microtips/UMSH-8596MD-20T
    ../../../../../../Source/Devices/LCD/MicroTips/UMSH-8596MD-20T/: Microtips_UMSH_8596MD_20T.c
  group Devuce/Touchscreen/Sitronix/ST1232
    ../../../../../../Source/Devices/Touchscreen/Sitronix/ST1232/: ST1232TouchScreen.c
  group Device/AudioAmp/Wolfson/WM8731
    ../../../../../../Source/Devices/AudioAmp/Wolfson/WM8731/: AudioAmp_WM8731.c
  group Device/I2C/Mux/PCA9546
    ../../../../../../Source/Devices/I2C/Mux/PCA9546/: I2C_Mux_PCA9546.c I2C_Mux_PCA9546.h
  group Library/Tests/ALS/Vishay/VCNL4010
    ../../../../../../Source/Library/Tests/ALS/Vishay/VCNL4010/: TestVCNL4010.c TestVCNL4010.h
  group NewHaven_NHD50800480TF
    ../../../../../../Source/Devices/LCD/NewHaven/NHD50800480TF/: NewHaven_NHD50800480TF.c NewHaven_NHD50800480TF.h
  group Devices\Accelerometer\ST\LIS3DH
    ../../../../../../Source/Devices/Accelerometer/ST/LIS3DH/: ST_LIS3DH_I2C_driver.c
  group Encryption/CyaSSL
    ../../../../../../Source/Library/Encryption/CyaSSL/ctaocrypt/src/: aes.c arc4.c asn.c coding.c des3.c dh.c dsa.c error.c hc128.c hmac.c integer.c logging.c md4.c memory.c misc.c pwdbased.c rabbit.c random.c ripemd.c rsa.c sha.c sha256.c sha512.c tfm.c wc_port.c
    ../../../../../../Source/Library/Encryption/CyaSSL/src/: internal.c io.c keys.c ssl.c tls.c
  group Library/USBDevice/LPCUSBLIB/VirtualCom
    ../../../../../../Source/Library/USBDevice/LPCUSBLib/VirtualComm/: VirtualComm.c
  group Devices/USBHost/Generic
    ../../../../../../Source/Devices/USBHost/Generic/: Generic_USBHost.c
  group Devices/Watchdog/Generic
    ../../../../../../Source/Devices/Watchdog/Generic/: Watchdog_Generic_driver.c
  group Library/Audio/MIDI
    ../../../../../../Source/Library/Audio/MIDI/: MIDIPlayer.c
  group Library/Console/FDI/FDICmd
    ../../../../../../Source/Library/Console/FDICmd/: FDICmd.c
  group Library/Console/FDI/FDICmd/Commands
    ../../../../../../Source/Library/Console/FDICmd/Commands/: FDICmd_File.c FDICmd_I2C.c FDICmd_File.h FDICmd_I2C.h FDICmd_AudioDAC.c FDICmd_AudioDAC.h FDICmd_WAVPlay.c FDICmd_WAVPlay.h
  group Library/GUI/FDI/SimpleUI
    ../../../../../../Source/Library/GUI/FDI/SimpleUI/: SimpleUI.h SimpleUI_Choices.c SimpleUI_Choices.h SimpleUI_Drawing.c SimpleUI_Drawing.h SimpleUI_Regions.c SimpleUI_Regions.h SimpleUI_Types.h SimpleUI_UtilityFunctions.c SimpleUI_UtilityFunctions.h SimpleUI_DrawBitmap.h SimpleUI_DrawBitmap.c
  group Library/Language/C
    ../../../../../../Source/Library/Language/C/: itoa.c ltoa.c ultoa.c
  group Library/lwIP
    ../../../../../../Source/Library/lwIP/Include/: lwippools.h
    ../../../../../../Source/Library/lwIP/src/api/: tcpip.c api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c
    ../../../../../../Source/Library/lwIP/src/arch/: sys_arch.c clock.c
    ../../../../../../Source/Library/lwIP/src/core/: udp.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c
    ../../../../../../Source/Library/lwIP/src/core/ipv4/: ip_frag.c autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c
    ../../../../../../Source/Library/lwIP/src/core/snmp/: msg_out.c asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c
    ../../../../../../Source/Library/lwIP/src/include/ipv4/lwip/: ip_frag.h autoip.h icmp.h igmp.h inet.h inet_chksum.h ip.h ip_addr.h
    ../../../../../../Source/Library/lwIP/src/include/netif/: slipif.h etharp.h loopif.h ppp_oe.h
    ../../../../../../Source/Library/lwIP/src/include/lwip/: udp.h api.h api_msg.h arch.h debug.h def.h dhcp.h dns.h err.h init.h mem.h memp.h memp_std.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h snmp_asn1.h snmp_msg.h snmp_structs.h sockets.h stats.h sys.h tcp.h tcpip.h
    ../../../../../../Source/Library/lwIP/src/netif/: slipif.c etharp.c loopif.c ethernetif.c
    ../../../../../../Source/Library/lwIP/: uEZEMAC_lwIP.c
  group Library/Memory/MemoryTest
    ../../../../../../Source/Library/Memory/MemoryTest/: MemoryTest.c
  group Library/Network/PHY/MDIOBitBang
    ../../../../../../Source/Library/Network/PHY/MDIOBitBang/: MDIOBitBang.c MDIOBitBang.h
  group Library/Parser/IntelHexParser
    ../../../../../../Source/Library/Parser/IntelHexParser/: IntelHexParser.c
  group Library/StreamIO/StdInOut
    ../../../../../../Source/Library/StreamIO/StdInOut/: StdInOut.c
    ../../../../../../Source/Library/StreamIO/StdInOut/Keil/: StdInOut_Keil.c
  group Library/uEZFailure
    ../../../../../../Source/Library/uEZFailure/: FatalError.c uEZFailure.c
  group Library/Web/BasicWEB
    ../../../../../../Source/Library/Web/BasicWeb/: BasicWEB.c
  group Library/Web/HTTPServer
    ../../../../../../Source/Library/Web/HTTPServer/: HTTPServer.c HTTPServer.h
  group Processor/NXP/LPC43xx
    ../../../../../../Source/Processor/NXP/LPC43xx/: LPC43xx_ADCBank.c LPC43xx_ADCBank.h LPC43xx_DAC.c LPC43xx_DAC.h LPC43xx_EMAC.c LPC43xx_EMAC.h LPC43xx_EMC_Static.c LPC43xx_EMC_Static.h LPC43xx_ExternalBus.c LPC43xx_ExternalBus.h LPC43xx_GPDMA.c LPC43xx_GPDMA.h LPC43xx_GPIO.c LPC43xx_GPIO.h LPC43xx_HALInit.c LPC43xx_I2C.c LPC43xx_I2C.h LPC43xx_I2S.c LPC43xx_I2S.h LPC43xx_Interrupt.c LPC43xx_LCDController.c LPC43xx_LCDController.h LPC43xx_PLL.c LPC43xx_PLL.h LPC43xx_PWM.c LPC43xx_PWM.h LPC43xx_RTC.c LPC43xx_RTC.h LPC43xx_SDRAM.c LPC43xx_SDRAM.h LPC43xx_Serial.c LPC43xx_Serial.h LPC43xx_SSP.c LPC43xx_SSP.h LPC43xx_Timer.c LPC43xx_Timer.h LPC43xx_USBDeviceController.c LPC43xx_USBDeviceController.h LPC43xx_USBSharedInterrupt.c LPC43xx_UtilityFuncs.c LPC43xx_UtilityFuncs.h LPC43xx_Watchdog.c LPC43xx_Watchdog.h uEZProcessor_LPC43xx.h LPC43xx_USBHost.c LPC43xx_CAN.c LPC43xx_CAN.h LPC43xx_MCI.h LPC43xx_SD_MMC.c LPC43xx_SD_MMC.h LPC43xx_USBHost.h
  group RTOS/FreeRTOS
    ../../../../../../Source/RTOS/FreeRTOS/include/: FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h
    ../../../../../../Source/RTOS/FreeRTOS/: list.c queue.c tasks.c timers.c
    ../../../../../../Source/RTOS/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
    ../../../../../../Source/RTOS/FreeRTOS/portable/MemMang/: heap_3.c
    ../../../../../../Source/RTOS/: uEZRTOS.c
  group RTOS/FreeRTOS-Plus/FreeRTOS-Plus-Trace
    ../../../../../../Source/RTOS/FreeRTOS-Plus/FreeRTOS-Plus-Trace/: trcBase.c trcHardwarePort.c trcKernel.c trcKernelPort.c trcUser.c
  group uEZSystem
    ../../../../../../Source/uEZSystem/: HAL.c uEZAccelerometer.c uEZADC.c uEZAudioAmp.c uEZBSPInit.c uEZButton.c uEZCharDisplay.c uEZDAC.c uEZDeviceTable.c uEZEINT.c uEZFile.c uEZFlash.c uEZGPIO.c uEZHandles.c uEZHandles.h uEZHID.c uEZI2C.c uEZINI.c uEZInit.c uEZKeypad.c uEZLCD.c uEZLEDBank.c uEZMemory.c uEZNetwork.c uEZPWM.c uEZRandom.c uEZResourceCache.c uEZSPI.c uEZStream.c uEZTemperature.c uEZTimeDate.c uEZTimer.c uEZToneGenerator.c uEZTS.c uEZWatchdog.c uEZWAVFile.c uEZEEPROM.c uEZAudioMixer.c
  group Library/ScreenSaver
    ../../../../../../Source/Library/ScreenSaver/: BouncingLogoSS.c
  group Library/Audio/DAC
    ../../../../../../Source/Library/Audio/DAC/: UEZDACWavFile.c
  group Device/GPIO/I2C/PCF8574T
    ../../../../../../Source/Devices/GPIO/I2C/PCF8574T/: GPIO_PCF8574T.c GPIO_PCF8574T.h
  group Source\Devices\Keypad\GPIO
    ../../../../../../Source/Devices/Keypad/GPIO/: Keypad_Generic_GPIO.c Keypad_Generic_GPIO.h
  group Device/AudioAmp/TI/LM48100
    ../../../../../../Source/Devices/AudioAmp/TI/LM48100/: AudioAmp_LM48100.c
  group Device/LCD/Microtips/UMSH-8596MD-20T
    ../../../../../../Source/Devices/LCD/MicroTips/UMSH-8596MD-20T/: Microtips_UMSH_8596MD_20T.c
  group Devuce/Touchscreen/Sitronix/ST1232
    ../../../../../../Source/Devices/Touchscreen/Sitronix/ST1232/: ST1232TouchScreen.c
  group Device/AudioAmp/Wolfson/WM8731
    ../../../../../../Source/Devices/AudioAmp/Wolfson/WM8731/: AudioAmp_WM8731.c
  group Device/I2C/Mux/PCA9546
    ../../../../../../Source/Devices/I2C/Mux/PCA9546/: I2C_Mux_PCA9546.c I2C_Mux_PCA9546.h
  group Library/Tests/ALS/Vishay/VCNL4010
    ../../../../../../Source/Library/Tests/ALS/Vishay/VCNL4010/: TestVCNL4010.c TestVCNL4010.h
  group Newhaven
    ../../../../../../Source/Devices/LCD/NewHaven/NHD43480272MF/: NewHaven_NHD43480272MF.c
    ../../../../../../Source/Devices/Touchscreen/Newhaven/FT5306DE4/: FT5306DE4TouchScreen.c
  group Source/Library/LPCOpen
    ../../../../../../Source/Library/LPCOpen/chip_18xx_43xx/: chip_18xx_43xx.c clock_18xx_43xx.c clock_18xx_43xx.h rgu_18xx_43xx.c rgu_18xx_43xx.h sdif_18xx_43xx.c sdif_18xx_43xx.h sdmmc_18xx_43xx.c sdmmc_18xx_43xx.h
  group Source/Library/LPCUSBLib
    ../../../../../../Source/Library/LPCOpen/LPCUSBLib/: LPCUSBLib_uEZ.c LPCUSBLib_uEZ.h LPCUSBlibConfig.h Version.h
  group Source/Library/LPCOpen/LPCUSBLIB/Drivers
    ../../../../../../Source/Library/LPCOpen/LPCUSBLib/Drivers/USB/Class/Host/: AudioClassHost.c CDCClassHost.c HIDClassHost.c MassStorageClassHost.c MIDIClassHost.c PrinterClassHost.c RNDISClassHost.c StillImageClassHost.c
    ../../../../../../Source/Library/LPCOpen/LPCUSBLib/Drivers/USB/Class/Device/: AudioClassDevice.c CDCClassDevice.c HIDClassDevice.c MassStorageClassDevice.c MIDIClassDevice.c RNDISClassDevice.c
    ../../../../../../Source/Library/LPCOpen/LPCUSBLib/Drivers/USB/Class/Common/: HIDParser.c
    ../../../../../../Source/Library/LPCOpen/LPCUSBLib/Drivers/USB/Class/: CDCClass.h
    ../../../../../../Source/Library/LPCOpen/LPCUSBLib/Drivers/USB/Core/: ConfigDescriptor.c ConfigDescriptor.h Device.c Device.h DeviceStandardReq.c DeviceStandardReq.h Endpoint.c Endpoint.h EndpointStream.c EndpointStream.h Events.c Events.h Host.c Host.h HostStandardReq.c HostStandardReq.h OTG.h Pipe.c Pipe.h PipeStream.c PipeStream.h StdDescriptors.h StdRequestType.h USBController.c USBController.h USBInterrupt.h USBMemory.c USBMemory.h USBMode.h USBTask.c USBTask.h
    ../../../../../../Source/Library/LPCOpen/LPCUSBLib/Drivers/USB/Core/DCD/: EndpointCommon.h
    ../../../../../../Source/Library/LPCOpen/LPCUSBLib/Drivers/USB/Core/DCD/LPC18XX/: Device_LPC18xx.h Endpoint_LPC18xx.c Endpoint_LPC18xx.h
    ../../../../../../Source/Library/LPCOpen/LPCUSBLib/Drivers/USB/Core/HAL/: HAL.h
    ../../../../../../Source/Library/LPCOpen/LPCUSBLib/Drivers/USB/Core/HAL/LPC18XX/: HAL_LPC18xx.c HAL_LPC18xx.h
    ../../../../../../Source/Library/LPCOpen/LPCUSBLib/Drivers/USB/Core/HCD/: HCD.c HCD.h
    ../../../../../../Source/Library/LPCOpen/LPCUSBLib/Drivers/USB/Core/HCD/EHCI/: EHCI.c EHCI.h
  group Devices/CRC/Software
    ../../../../../../Source/Devices/CRC/Software/: CRC_Software.c CRC_Software.h
software components: CMSIS:CORE 5.0.0
