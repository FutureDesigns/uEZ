# IAR project uEZ_NXP_LPC4357_FreeRTOS_IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: LWIP_PROVIDE_ERRNO; UEZ_LIBRARY; LWIP_2_0_x; CORE_M4; DEBUG
  ICCARM.CCDiagSuppress: Pe193,Pe826,Pe068
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCIncludePath2: .; ../.; ../../../../../../.; ../../../../../../Include; ../../../../../../Source/RTOS/FreeRTOS/include; ../../../../../../Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../../../Source/Processor/NXP/LPC43xx; ../../../../../../Source/Processor/NXP/LPC43xx/IAR/; ../../../../../../Source/Processor/NXP/LPC43xx/Common/; ../../../../../../Source/Processor/NXP/LPC43xx/Common/include; ../../../../../../Source/Processor/NXP/LPC43xx/Common/include/CMSIS; ../../../../../../Source/RTOS/FreeRTOS/; ../../../../../../Source/Library/lwIP_2.0.x/src/include; ../../../../../../Source/Library/lwIP_2.0.x/src; ../../../../../../Source/Library/lwIP_2.0.x/Include; ../../../../../../Source/Library/lwIP_2.0.x/src/include/ipv4; ../../../../../../Source/Library/lwIP_2.0.x/system; ../../../../../../Source/Library/lwIP_2.0.x/system/arch; ../../../../../../Source/Platform/emWin/Inc; ../../../../../../Source/Platform/emWin/Config; ../../../../../../Source/Library/GUI/SEGGER/emWin; ../../../../../../Source/Library/SEGGER/SystemView/; ../../../../../../Source/Library/SEGGER/RTT/; ../../../../../../Source/Library/LPCOpen; ../../../../../../Source/Library/LPCOpen/chip_18xx_43xx
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M4; DEBUG
  AARM.AUserIncludes: .; ../.; ../../../../../../.; ../../../../../../Include; ../../../../../../Source/Processor/NXP/LPC43xx; ../../../../../../Source/Processor/NXP/LPC43xx/IAR/; ../../../../../../Source/Processor/NXP/LPC43xx/Common/; ../../../../../../Source/Processor/NXP/LPC43xx/Common/include; ../../../../../../Source/Processor/NXP/LPC43xx/Common/include/CMSIS; ../../../../../../Source/RTOS/FreeRTOS/include; ../../../../../../Source/RTOS/FreeRTOS; ../../../../../../Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../../../Source/Library/lwIP_2.0.x/src/include; ../../../../../../Source/Library/lwIP_2.0.x/src; ../../../../../../Source/Library/lwIP_2.0.x/Include; ../../../../../../Source/Library/lwIP_2.0.x/src/include/ipv4; ../../../../../../Source/Library/lwIP_2.0.x/system; ../../../../../../Source/Library/lwIP_2.0.x/system/arch; ../../../../../../Source/Library/Encryption/CyaSSL; ../../../../../../Source/Library/Encryption/CyaSSL/cyassl; ../../../../../../Source/Library/Encryption/CyaSSL/cyassl/ctaocrypt; ../../../../../../Source/Library/Encryption/CyaSSL/cyassl/openssl
  OBJCOPY.OOCOutputFile: UEZGUIDemo.hex
  ILINK.IlinkOutputFile: uEZ_NXP_LPC4357_FreeRTOS_IAR.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug-TouchGFX (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: LWIP_PROVIDE_ERRNO; UEZ_LIBRARY; IAR_ARM_CM4F; CORE_M4; LWIP_2_0_x; TOUCHGFX
  ICCARM.CCDiagSuppress: Go005, Go004,Pe061
  ICCARM.CCIncludePath2: .; ../.; ../../../../../../.; ../../../../../../Include; ../../../../../../Source/Processor/NXP/LPC43xx; ../../../../../../Source/Processor/NXP/LPC43xx/IAR/; ../../../../../../Source/Processor/NXP/LPC43xx/Common/; ../../../../../../Source/Processor/NXP/LPC43xx/Common/include; ../../../../../../Source/Processor/NXP/LPC43xx/Common/include/CMSIS; ../../../../../../Source/RTOS/FreeRTOS/include; ../../../../../../Source/RTOS/FreeRTOS/; ../../../../../../Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../../../Source/Library/lwIP_2.0.x/src/include; ../../../../../../Source/Library/lwIP_2.0.x/src; ../../../../../../Source/Library/lwIP_2.0.x/Include; ../../../../../../Source/Library/lwIP_2.0.x/src/include/ipv4; ../../../../../../Source/Library/lwIP_2.0.x/system; ../../../../../../Source/Library/lwIP_2.0.x/system/arch; ../../../../../../Source/Platform/emWin/Inc; ../../../../../../Source/Platform/emWin/Config; ../../../../../../Source/Library/GUI/SEGGER/emWin; ../../../../../../Source/Library/LPCOpen; ../../../../../../Source/Library/LPCOpen/chip_18xx_43xx
  AARM.AUserIncludes: .; ../.; ../../../../../../.; ../../../../../../Include; ../../../../../../Source/Processor/NXP/LPC43xx; ../../../../../../Source/Processor/NXP/LPC43xx/IAR/; ../../../../../../Source/Processor/NXP/LPC43xx/Common/; ../../../../../../Source/Processor/NXP/LPC43xx/Common/include; ../../../../../../Source/Processor/NXP/LPC43xx/Common/include/CMSIS; ../../../../../../Source/RTOS/FreeRTOS/include; ../../../../../../Source/RTOS/FreeRTOS/; ../../../../../../Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../../../Source/Library/lwIP_2.0.x/src/include; ../../../../../../Source/Library/lwIP_2.0.x/src; ../../../../../../Source/Library/lwIP_2.0.x/Include; ../../../../../../Source/Library/lwIP_2.0.x/src/include/ipv4; ../../../../../../Source/Library/lwIP_2.0.x/system; ../../../../../../Source/Library/lwIP_2.0.x/system/arch; ../../../../../../Source/Platform/emWin/Inc; ../../../../../../Source/Platform/emWin/Config; ../../../../../../Source/Library/GUI/SEGGER/emWin
configuration Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: LWIP_PROVIDE_ERRNO; UEZ_LIBRARY; CORE_M4; LWIP_2_0_x; NDEBUG
  ICCARM.CCIncludePath2: .; ../.; ../../../../../../.; ../../../../../../Include; ../../../../../../Source/Processor/NXP/LPC43xx; ../../../../../../Source/Processor/NXP/LPC43xx/IAR/; ../../../../../../Source/Processor/NXP/LPC43xx/Common/; ../../../../../../Source/Processor/NXP/LPC43xx/Common/include; ../../../../../../Source/Processor/NXP/LPC43xx/Common/include/CMSIS; ../../../../../../Source/RTOS/FreeRTOS/include; ../../../../../../Source/RTOS/FreeRTOS/; ../../../../../../Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../../../Source/Library/SEGGER/SystemView/; ../../../../../../Source/Library/SEGGER/RTT/; ../../../../../../Source/Library/lwIP_2.0.x/src/include; ../../../../../../Source/Library/lwIP_2.0.x/src; ../../../../../../Source/Library/lwIP_2.0.x/Include; ../../../../../../Source/Library/lwIP_2.0.x/src/include/ipv4; ../../../../../../Source/Library/lwIP_2.0.x/system; ../../../../../../Source/Library/lwIP_2.0.x/system/arch; ../../../../../../Source/Platform/emWin/Inc; ../../../../../../Source/Platform/emWin/Config; ../../../../../../Source/Library/GUI/SEGGER/emWin; ../../../../../../Source/Library/LPCOpen; ../../../../../../Source/Library/LPCOpen/chip_18xx_43xx
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: CORE_M4; NDEBUG
  AARM.AUserIncludes: ; .; ../.; ../../../../../../.; ../../../../../../Include; ../../../../../../Source/Processor/NXP/LPC43xx; ../../../../../../Source/Processor/NXP/LPC43xx/IAR/; ../../../../../../Source/Processor/NXP/LPC43xx/Common/; ../../../../../../Source/Processor/NXP/LPC43xx/Common/include; ../../../../../../Source/Processor/NXP/LPC43xx/Common/include/CMSIS; ../../../../../../Source/RTOS/FreeRTOS/include; ../../../../../../Source/RTOS/FreeRTOS/; ../../../../../../Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../../../Source/Library/lwIP_2.0.x/src/include; ../../../../../../Source/Library/lwIP_2.0.x/src; ../../../../../../Source/Library/lwIP_2.0.x/Include; ../../../../../../Source/Library/lwIP_2.0.x/src/include/ipv4; ../../../../../../Source/Library/lwIP_2.0.x/system; ../../../../../../Source/Library/lwIP_2.0.x/system/arch; ../../../../../../Source/Platform/emWin/Inc; ../../../../../../Source/Platform/emWin/Config; ../../../../../../Source/Library/GUI/SEGGER/emWin
configuration Release-Bootloader (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: UEZ_LIBRARY; CORE_M4; NDEBUG; DISABLE_FILESYSTEM_FORMAT_SUPPORT=1; DISABLE_FEATURES_FOR_BOOTLOADER=1
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: CORE_M4; NDEBUG
  AARM.AUserIncludes: as above
  group (top)
    ../: Config_Build.h
    ../../../../../../Source/RTOS/FreeRTOS/include/: FreeRTOSConfig.h
    ../../../../../../Include/: SEGGER_RTT_SYSVIEW_Config.h
    ./: uEZPlatform.h
  group Include
    ../../../../../../Include/: build_time.h Config.h fcntl.h Global.h lwipopts.h lwippools.h netdb.h signal.h uEZ.h uEZAccelerometer.h uEZADC.h uEZAudioAmp.h uEZAudioMixer.h uEZBSP.h uEZButton.h uEZCAN.h uEZCharDisplay.h uEZCRC.h uEZDAC.h uEZDevice.h uEZDeviceTable.h uEZEEPROM.h uEZEINT.h uEZErrors.h uEZFile.h uEZFlash.h uEZGPIO.h uEZHID.h uEZI2C.h uEZINI.h uEZInline.h uEZKeypad.h uEZLCD.h uEZLEDBank.h uEZMemory.h uEZNetwork.h uEZPacked.h uEZPlatformAPI.h uEZProcessor.h uEZPWM.h uEZRandom.h uEZResourceCache.h uEZRTOS.h uEZSPI.h uEZStream.h uEZTemperature.h uEZTickCounter.h uEZTimeDate.h uEZTimer.h uEZToneGenerator.h uEZTS.h uEZTypes.h uEZWatchdog.h uEZWAVFile.h unistd.h
  group Include/Device
    ../../../../../../Include/Device/: Accelerometer.h ADCBank.h AudioAmp.h AudioCodec.h Backlight.h ButtonBank.h CharDisplay.h DAC.h EEPROM.h ExternalInterrupt.h FileSystem.h Flash.h GPDMA.h HID.h I2CBus.h I2S.h Keypad.h LCD.h LEDBank.h LightSensor.h MassStorage.h Network.h PWM.h ResourceCache.h RTC.h SPIBus.h Stream.h Temperature.h Timer.h ToneGenerator.h Touchscreen.h USBDevice.h USBHost.h Watchdog.h
  group Include/Device/LCD
    ../../../../../../Include/Device/LCD/: Config_LCD.h
  group Include/HAL
    ../../../../../../Include/HAL/: ADCBank.h BatteryRAM.h CRC.h DAC.h EEPROM.h EMAC.h ExternalInterrupt.h GPDMA.h GPIO.h HAL.h I2CBus.h I2SBus.h Interrupt.h LCDController.h PWM.h RTC.h Serial.h SPI.h Timer.h USBDeviceController.h USBHost.h Watchdog.h
  group Include/netinet
    ../../../../../../Include/netinet/: in.h
  group Include/sys
    ../../../../../../Include/sys/: mman.h socket.h stat.h time.h types.h
  group Include/Types
    ../../../../../../Include/Types/: Accelerometer.h ADC.h CRC.h EEPROM.h EINT.h EMAC.h File.h Flash.h GPDMA.h GPIO.h I2C.h I2S.h InputEvent.h LCD.h Network.h SDRAM.h Serial.h SPI.h TimeDate.h Timer.h USBDevice.h USBHost.h WAVFile.h
  group Source/Devices/Accelerometer/Analog Devices/ADXL345
    ../../../../../../Source/Devices/Accelerometer/Analog Devices/ADXL345/: Accelerometer_ADXL345.c Accelerometer_ADXL345.h
  group Source/Devices/Accelerometer/Bosch/BMA150
    ../../../../../../Source/Devices/Accelerometer/Bosch/BMA150/: Bosch_BMA150_I2C.h Bosch_BMA150_I2C_driver.c
  group Source/Devices/Accelerometer/Freescale/MMA7455
    ../../../../../../Source/Devices/Accelerometer/Freescale/MMA7455/: Freescale_MMA7455.h Freescale_MMA7455_driver.c
  group Source/Devices/Accelerometer/ST/LIS3DH
    ../../../../../../Source/Devices/Accelerometer/ST/LIS3DH/: ST_LIS3DH_I2C.h ST_LIS3DH_I2C_driver.c
  group Source/Devices/Accelerometer/ST/LIS3LV02DQ
    ../../../../../../Source/Devices/Accelerometer/ST/LIS3LV02DQ/: ST_LIS3LV02DQ_I2C.h ST_LIS3LV02DQ_I2C_driver.c
  group Source/Devices/ADC/Generic
    ../../../../../../Source/Devices/ADC/Generic/: Generic_adc.c
  group Source/Devices/Audio Codec/Wolfson/WM8731
    ../../../../../../Source/Devices/Audio Codec/Wolfson/WM8731/: AudioCodec_WM8731.c AudioCodec_WM8731.h
  group Source/Devices/AudioAmp/NXP/TDA8551_T
    ../../../../../../Source/Devices/AudioAmp/NXP/TDA8551_T/: AudioAmp_8551T.c
  group Source/Devices/AudioAmp/TI/LM48100
    ../../../../../../Source/Devices/AudioAmp/TI/LM48100/: AudioAmp_LM48100.c AudioAmp_LM48100.h
  group Source/Devices/AudioAmp/Wolfson/WM8731
    ../../../../../../Source/Devices/AudioAmp/Wolfson/WM8731/: AudioAmp_WM8731.c AudioAmp_WM8731.h
  group Source/Devices/Backlight/Generic/BacklightPWMControlled
    ../../../../../../Source/Devices/Backlight/Generic/BacklightPWMControlled/: BacklightPWMControlled.c
  group Source/Devices/Button/NXP/PCA9551
    ../../../../../../Source/Devices/Button/NXP/PCA9551/: Button_NXP_PCA9551_driver.c
  group Source/Devices/CRC/Generic
    ../../../../../../Source/Devices/CRC/Generic/: CRC_Generic.c
  group Source/Devices/CRC/Software
    ../../../../../../Source/Devices/CRC/Software/: CRC_Software.c CRC_Software.h
  group Source/Devices/DAC/Generic
    ../../../../../../Source/Devices/DAC/Generic/: DAC_Generic.c
  group Source/Devices/EEPROM/Generic/I2C
    ../../../../../../Source/Devices/EEPROM/Generic/I2C/: EEPROM16_Generic_I2C.h EEPROM16_Generic_I2C_driver.c EEPROM_Generic_I2C.h EEPROM_Generic_I2C_driver.c
  group Source/Devices/EEPROM/NXP/LPC43xx
    ../../../../../../Source/Devices/EEPROM/NXP/LPC43xx/: EEPROM_NXP_LPC43xx.c EEPROM_NXP_LPC43xx.h
  group Source/Devices/ExternalInterrupt/Generic
    ../../../../../../Source/Devices/ExternalInterrupt/Generic/: ExternalInterrupt_Generic.c ExternalInterrupt_Generic.h
  group Source/Devices/Flash/NXP/LPC_SPIFI_M4F
    ../../../../../../Source/Devices/Flash/NXP/LPC_SPIFI_M4F/: Flash_NXP_LPC_SPIFI_M4.h Flash_NXP_LPC_SPIFI_M4_driver.c spifilib_api.h spifilib_chiphw.h spifilib_dev.h spifilib_dev_common.c spifilib_fam_standard_cmd.c
  group Source/Devices/Flash/Spansion/S29GL
    ../../../../../../Source/Devices/Flash/Spansion/S29GL/: Flash_S29GL064N90_16bit_driver.c
  group Source/Devices/GPDMA/Generic
    ../../../../../../Source/Devices/GPDMA/Generic/: Generic_GPDMA.c
  group Source/Devices/GPIO/I2C/PCA9532
    ../../../../../../Source/Devices/GPIO/I2C/PCA9532/: GPIO_PCA9532.c GPIO_PCA9532.h
  group Source/Devices/GPIO/I2C/PCF8574T
    ../../../../../../Source/Devices/GPIO/I2C/PCF8574T/: GPIO_PCF8574T.c GPIO_PCF8574T.h
  group Source/Devices/HID/Generic
    ../../../../../../Source/Devices/HID/Generic/: HID_Generic.c
  group Source/Devices/I2C/Generic
    ../../../../../../Source/Devices/I2C/Generic/: Generic_i2c.c
  group Source/Devices/I2C/Mux/PCA9546
    ../../../../../../Source/Devices/I2C/Mux/PCA9546/: I2C_Mux_PCA9546.c I2C_Mux_PCA9546.h
  group Source/Devices/I2S/Generic
    ../../../../../../Source/Devices/I2S/Generic/: Generic_i2s.c Generic_I2S.h
  group Source/Devices/Keypad/GPIO
    ../../../../../../Source/Devices/Keypad/GPIO/: Keypad_Generic_GPIO.c Keypad_Generic_GPIO.h
  group Source/Devices/Keypad/NXP/I2C_Keypad
    ../../../../../../Source/Devices/Keypad/NXP/I2C_Keypad/: Keypad_NXP_I2C_PCA9555.h Keypad_NXP_I2C_PCA9555_driver.c
  group Source/Devices/LCD/Innolux/AT070TN84
    ../../../../../../Source/Devices/LCD/Innolux/AT070TN84/: Innolux_AT070TN84.c Innolux_AT070TN84.h
  group Source/Devices/LCD/Newhaven/NHD50800480TF
    ../../../../../../Source/Devices/LCD/NewHaven/NHD50800480TF/: NewHaven_NHD50800480TF.c NewHaven_NHD50800480TF.h NewHaven_NHD50800480TF_Rev2.c
  group Source/Devices/LCD/Newhaven/NHD70800480EF
    ../../../../../../Source/Devices/LCD/NewHaven/NHD70800480EF/: NewHaven_NHD70800480EF.c NewHaven_NHD70800480EF.h
  group Source/Devices/LED/Generic/GPIO
    ../../../../../../Source/Devices/LED/Generic/GPIO/: LED_Generic_GPIO.c LED_Generic_GPIO.h
  group Source/Devices/LED/NXP/PCA9551
    ../../../../../../Source/Devices/LED/NXP/PCA9551/: LED_NXP_PCA9551_driver.c
  group Source/Devices/Mass Storage/LPCUSBLib
    ../../../../../../Source/Devices/MassStorage/LPCUSBLib/: LPCUSBLib_MS.c LPCUSBLib_MS.h
  group Source/Devices/Mass Storage/SDCard
    ../../../../../../Source/Devices/MassStorage/SDCard/: SDCard_MS_driver_SD_MMC.c SDCard_MS_driver_SD_MMC.h SDCard_MS_driver_SPI.c
  group Source/Devices/Network/Gainspan
    ../../../../../../Source/Devices/Network/GainSpan/: Network_GainSpan.c Network_GainSpan.h
  group Source/Devices/Network/lwIP
    ../../../../../../Source/Devices/Network/lwIP/: Network_lwIP.c
  group Source/Devices/PWM/Generic
    ../../../../../../Source/Devices/PWM/Generic/: Generic_PWM.c
  group Source/Devices/ResourceCache/Generic/DirectAccess
    ../../../../../../Source/Devices/ResourceCache/Generic/DirectAccess/: ResourceCache_DirectAccess.c ResourceCache_DirectAccess.h
  group Source/Devices/RTC/Generic
    ../../../../../../Source/Devices/RTC/Generic/: generic_rtc.c
  group Source/Devices/RTC/NXP/PCF2129
    ../../../../../../Source/Devices/RTC/NXP/PCF2129/: RTC_PCF2129.c RTC_PCF2129.h
  group Source/Devices/RTC/NXP/PCF8563
    ../../../../../../Source/Devices/RTC/NXP/PCF8563/: RTC_PCF8563.c RTC_PCF8563.h
  group Source/Devices/Serial/Generic
    ../../../../../../Source/Devices/Serial/Generic/: uEZSerialGeneric.c uEZSerialGenericHalfDuplex.c
  group Source/Devices/Serial/LPCUSBLib/SerailHostFTDI
    ../../../../../../Source/Devices/Serial/LPCUSBLib/SerialHost_FTDI/: Stream_LPCUSBLib_SerialHost_FTDI.c Stream_LPCUSBLib_SerialHost_FTDI.h
  group Source/Devices/Serial/RS485/Generic
    ../../../../../../Source/Devices/Serial/RS485/Generic/: Generic_RS485.c Generic_RS485.h Generic_RS485_Timer.c Generic_RS485_Timer.h
  group Source/Devices/SPI/Generic
    ../../../../../../Source/Devices/SPI/Generic/: Generic_spi.c Generic_SPI.h
  group Source/Devices/Stream/LPCUSBLib/SerialHost
    ../../../../../../Source/Devices/Stream/LPCUSBLib/SerialHost/: Stream_LPCUSBLib_SerialHost.c Stream_LPCUSBLib_SerialHost.h
  group Source/Devices/Temperature/Analog Devices/ADT7420
    ../../../../../../Source/Devices/Temperature/Analog Devices/ADT7420/: Temperature_ADT7420.c Temperature_ADT7420.h
  group Source/Devices/Temperature/NXP/LM75A
    ../../../../../../Source/Devices/Temperature/NXP/LM75A/: Temperature_LM75A_driver.c
  group Source/Devices/Temperature/NXP/SA56004X
    ../../../../../../Source/Devices/Temperature/NXP/SA56004X/: Temperature_SA56004X.h Temperature_SA56004X_driver.c
  group Source/Devices/Timer/Generic
    ../../../../../../Source/Devices/Timer/Generic/: Timer_Generic.c Timer_Generic.h
  group Source/Devices/ToneGenerator/Generic/PWM
    ../../../../../../Source/Devices/ToneGenerator/Generic/PWM/: ToneGenerator_Generic_PWM_driver.c
  group Source/Devices/ToneGenerator/Generic/Timer
    ../../../../../../Source/Devices/ToneGenerator/Generic/Timer/: ToneGenerator_Generic_Timer.h ToneGenerator_Generic_Timer_driver.c
  group Source/Devices/Touchscreen/Generic/FourWireTouchResist
    ../../../../../../Source/Devices/Touchscreen/Generic/FourWireTouchResist/: FourWireTouchResist_TS.c FourWireTouchResist_TS.h
  group Source/Devices/Touchscreen/Newhaven/FT5306DE4
    ../../../../../../Source/Devices/Touchscreen/Newhaven/FT5306DE4/: FT5306DE4TouchScreen.c FT5306DE4TouchScreen.h
  group Source/Devices/Touchscreen/Sitronix/ST1232
    ../../../../../../Source/Devices/Touchscreen/Sitronix/ST1232/: ST1232TouchScreen.c ST1232TouchScreen.h
  group Source/Devices/Touchscreen/TI/TSC2046
    ../../../../../../Source/Devices/Touchscreen/TI/TSC2046/: Touchscreen_TI_TSC2046.c Touchscreen_TI_TSC2046.h
  group Source/Devices/USBHost/Generic
    ../../../../../../Source/Devices/USBHost/Generic/: Generic_USBHost.c
  group Source/Devices/Watchdog/Generic
    ../../../../../../Source/Devices/Watchdog/Generic/: Watchdog_Generic_driver.c
  group Source/Library/Audio/DAC
    ../../../../../../Source/Library/Audio/DAC/: uEZDACWAVFile.c uEZDACWAVFile.h
  group Source/Library/Console/FDICmd
    ../../../../../../Source/Library/Console/FDICmd/: FDICmd.c FDICmd.h
  group Source/Library/Console/FDICmd/Commands
    ../../../../../../Source/Library/Console/FDICmd/Commands/: FDICmd_AudioDAC.c FDICmd_AudioDAC.h FDICmd_File.c FDICmd_File.h FDICmd_I2C.c FDICmd_I2C.h FDICmd_WAVPlay.c FDICmd_WAVPlay.h
  group Source/Library/FileSystem/FATFS
    ../../../../../../Source/Library/FileSystem/FATFS/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c rtc.c rtc.h uEZFileSystem_FATFS.c uEZFileSystem_FATFS.h
  group Source/Library/Graphics/SWIM
    ../../../../../../Source/Library/Graphics/SWIM/: droidsansr32.c lpc_colors.h lpc_droidsansr14.c lpc_droidsansr14.h lpc_droidsansr76.c lpc_droidsansr76.h lpc_fonts.h lpc_helvr10.c lpc_helvr10.h lpc_rom8x16.c lpc_rom8x16.h lpc_rom8x8.c lpc_rom8x8.h lpc_swim.c lpc_swim.h lpc_swim_driver.c lpc_swim_driver.h lpc_swim_font.c lpc_swim_font.h lpc_swim_image.c lpc_swim_image.h lpc_types.h lpc_winfreesystem14x16.c lpc_winfreesystem14x16.h lpc_winfreesystem14x16_subset.c lpc_winfreesystem14x16_subset.h lpc_x5x7.c lpc_x5x7.h lpc_x6x13.c lpc_x6x13.h
  group Source/Library/GUI/FDI/SimpleUI
    ../../../../../../Source/Library/GUI/FDI/SimpleUI/: SimpleUI.h SimpleUI_Choices.c SimpleUI_Choices.h SimpleUI_DrawBitmap.c SimpleUI_DrawBitmap.h SimpleUI_Drawing.c SimpleUI_Drawing.h SimpleUI_Regions.c SimpleUI_Regions.h SimpleUI_Types.h SimpleUI_UtilityFunctions.c SimpleUI_UtilityFunctions.h
  group Source/Library/GUI/SEGGER/emWin
    ../../../../../../Source/Library/GUI/SEGGER/emWin/: AppWizard.h BUTTON.h BUTTON_Private.h CALENDAR.h CHECKBOX.h CHECKBOX_Private.h CHOOSECOLOR.h CHOOSEFILE.h DIALOG.h DIALOG_Type.h DROPDOWN.h DROPDOWN_Private.h EDIT.h EDIT_Private.h FRAMEWIN.h FRAMEWIN_Private.h GAUGE.h GAUGE_Private.h GRAPH.h GRAPH_Private.h GUI.h GUI__BiDi2_Brackets_800.h GUI__BiDi2_Types_800.h GUI_ARRAY.h GUI_ARRAY_Private.h GUI_BMP_Private.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_GCache_Private.h GUI_GIF_Private.h GUI_HOOK.h GUI_JPEG_Private.h GUI_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_SPRITE_Private.h GUI_SPY_Private.h GUI_Type.h GUI_Version.h GUI_VNC.h GUIDRV_BitPlains.h GUIDRV_DCache.h GUIDRV_DCache_Private.h GUIDRV_Dist.h GUIDRV_FlexColor.h GUIDRV_FlexColor_Private.h GUIDRV_IST3088.h GUIDRV_IST3088_Private.h GUIDRV_Lin.h GUIDRV_Lin_Opt_16.h GUIDRV_Lin_Opt_24.h GUIDRV_Lin_Opt_32.h GUIDRV_Lin_Opt_8.h GUIDRV_Lin_Private.h GUIDRV_NoOpt_1_8.h GUIDRV_S1D13748.h GUIDRV_S1D13748_Private.h GUIDRV_S1D13781.h GUIDRV_S1D13781_Private.h GUIDRV_S1D15G00.h GUIDRV_SH_MEM.h GUIDRV_SH_MEM_Private.h GUIDRV_SLin.h GUIDRV_SLin_Private.h GUIDRV_SPage.h GUIDRV_SPage_Private.h GUIDRV_SSD1926.h GUIDRV_SSD1926_Private.h GUIDRV_Template.h GUIDRV_TemplateI.h GUIDRV_TemplateI_Private.h GUITDRV_ADS7846.h HEADER.h HEADER_Private.h ICONVIEW.h ICONVIEW_Private.h IMAGE.h IMAGE_Private.h IP_FS.h KEYBOARD.h KEYBOARD_Private.h KNOB.h KNOB_Private.h LCD.h LCD_ConfDefaults.h LCD_Private.h LCD_Protected.h LCD_SIM.h LISTBOX.h LISTBOX_Private.h LISTVIEW.h LISTVIEW_Private.h LISTWHEEL.h LISTWHEEL_Private.h MENU.h MENU_Private.h MESSAGEBOX.h MULTIEDIT.h MULTIEDIT_Private.h MULTIPAGE.h MULTIPAGE_Private.h PROGBAR.h PROGBAR_Private.h QRCODE.h QRCODE_Private.h RADIO.h RADIO_Private.h ROTARY.h ROTARY_Private.h SCROLLBAR.h SCROLLBAR_Private.h SEGGER.h SLIDER.h SLIDER_Private.h SPINBOX.h SPINBOX_Private.h SWIPELIST.h SWIPELIST_Private.h SWITCH.h SWITCH_Private.h TEXT.h TEXT_Private.h TREEVIEW.h TREEVIEW_Private.h WIDGET.h WINDOW_Private.h WM.h WM_GUI.h WM_Intern.h
  group Source/Library/Language/C
    ../../../../../../Source/Library/Language/C/: C.h itoa.c ltoa.c ultoa.c
  group Source/Library/LPCOpen
    ../../../../../../Source/Library/LPCOpen/: board.c
  group Source/Library/LPCOpen/chip_18xx_43xx
    ../../../../../../Source/Library/LPCOpen/chip_18xx_43xx/: chip_18xx_43xx.c clock_18xx_43xx.c clock_18xx_43xx.h rgu_18xx_43xx.c rgu_18xx_43xx.h sdif_18xx_43xx.c sdif_18xx_43xx.h sdmmc_18xx_43xx.c sdmmc_18xx_43xx.h
  group Source/Library/LPCOpen/LPCUSBLib
    ../../../../../../Source/Library/LPCOpen/LPCUSBLib/: LPCUSBLib_uEZ.c LPCUSBLib_uEZ.h LPCUSBlibConfig.h Version.h
  group Source/Library/LPCOpen/LPCUSBLib/Drivers/USB
    ../../../../../../Source/Library/LPCOpen/LPCUSBLib/Drivers/USB/: USB.h
  group Source/Library/LPCOpen/LPCUSBLib/Drivers/USB/Class
    ../../../../../../Source/Library/LPCOpen/LPCUSBLib/Drivers/USB/Class/: MassStorageClass.h
  group Source/Library/LPCOpen/LPCUSBLib/Drivers/USB/Class/Common
    ../../../../../../Source/Library/LPCOpen/LPCUSBLib/Drivers/USB/Class/Common/: AudioClassCommon.h CDCClassCommon.h HIDClassCommon.h HIDParser.c HIDParser.h HIDReportData.h MassStorageClassCommon.h MIDIClassCommon.h PrinterClassCommon.h RNDISClassCommon.h StillImageClassCommon.h
  group Source/Library/LPCOpen/LPCUSBLib/Drivers/USB/Class/Device
    ../../../../../../Source/Library/LPCOpen/LPCUSBLib/Drivers/USB/Class/Device/: AudioClassDevice.c AudioClassDevice.h CDCClassDevice.c CDCClassDevice.h HIDClassDevice.c HIDClassDevice.h MassStorageClassDevice.c MassStorageClassDevice.h MIDIClassDevice.c MIDIClassDevice.h RNDISClassDevice.c RNDISClassDevice.h
  group Source/Library/LPCOpen/LPCUSBLib/Drivers/USB/Class/Host
    ../../../../../../Source/Library/LPCOpen/LPCUSBLib/Drivers/USB/Class/Host/: CDCClassHost.c CDCClassHost.h MassStorageClassHost.c MassStorageClassHost.h
  group Source/Library/LPCOpen/LPCUSBLib/Drivers/USB/Core
    ../../../../../../Source/Library/LPCOpen/LPCUSBLib/Drivers/USB/Core/: ConfigDescriptor.c ConfigDescriptor.h Device.c Device.h DeviceStandardReq.c DeviceStandardReq.h Endpoint.c Endpoint.h EndpointStream.c EndpointStream.h Events.c Events.h Host.c Host.h HostStandardReq.c HostStandardReq.h OTG.h Pipe.c Pipe.h PipeStream.c PipeStream.h StdDescriptors.h StdRequestType.h USBController.c USBController.h USBInterrupt.h USBMemory.c USBMemory.h USBMode.h USBTask.c USBTask.h
  group Source/Library/LPCOpen/LPCUSBLib/Drivers/USB/Core/DCD
    ../../../../../../Source/Library/LPCOpen/LPCUSBLib/Drivers/USB/Core/DCD/: EndpointCommon.h
  group Source/Library/LPCOpen/LPCUSBLib/Drivers/USB/Core/DCD/LPC18XX
    ../../../../../../Source/Library/LPCOpen/LPCUSBLib/Drivers/USB/Core/DCD/LPC18XX/: Device_LPC18xx.h Endpoint_LPC18xx.c Endpoint_LPC18xx.h
  group Source/Library/LPCOpen/LPCUSBLib/Drivers/USB/Core/HAL/LPC18XX
    ../../../../../../Source/Library/LPCOpen/LPCUSBLib/Drivers/USB/Core/HAL/LPC18XX/: HAL_LPC18xx.c HAL_LPC18xx.h
  group Source/Library/LPCOpen/LPCUSBLib/Drivers/USB/Core/HCD
    ../../../../../../Source/Library/LPCOpen/LPCUSBLib/Drivers/USB/Core/HCD/: HCD.c HCD.h
  group Source/Library/LPCOpen/LPCUSBLib/Drivers/USB/Core/HCD/EHCI
    ../../../../../../Source/Library/LPCOpen/LPCUSBLib/Drivers/USB/Core/HCD/EHCI/: EHCI.c EHCI.h
  group Source/Library/lwIP
    ../../../../../../Source/Library/lwIP/: uEZEMAC_lwIP.c
  group Source/Library/lwIP/src/api
    ../../../../../../Source/Library/lwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Source/Library/lwIP/src/arch
    ../../../../../../Source/Library/lwIP/src/arch/: bpstruct.h cc.h clock.c clock.h epstruct.h ethernetif.h lwIP_EMAC.h perf.h sys_arch.c sys_arch.h
  group Source/Library/lwIP/src/core
    ../../../../../../Source/Library/lwIP/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group Source/Library/lwIP/src/core/ipv4
    ../../../../../../Source/Library/lwIP/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group Source/Library/lwIP/src/core/snmp
    ../../../../../../Source/Library/lwIP/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
  group Source/Library/lwIP/src/include/ipv4/lwip
    ../../../../../../Source/Library/lwIP/src/include/ipv4/lwip/: autoip.h icmp.h igmp.h inet.h inet_chksum.h ip.h ip_addr.h ip_frag.h
  group Source/Library/lwIP/src/include/ipv6/lwip
    ../../../../../../Source/Library/lwIP/src/include/ipv6/lwip/: icmp.h inet.h ip.h ip_addr.h
  group Source/Library/lwIP/src/include/lwip
    ../../../../../../Source/Library/lwIP/src/include/lwip/: api.h api_msg.h arch.h debug.h def.h dhcp.h dns.h err.h init.h mem.h memp.h memp_std.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h snmp_asn1.h snmp_msg.h snmp_structs.h sockets.h stats.h sys.h tcp.h tcpip.h udp.h
  group Source/Library/lwIP/src/include/netif
    ../../../../../../Source/Library/lwIP/src/include/netif/: etharp.h loopif.h ppp_oe.h slipif.h
  group Source/Library/lwIP/src/netif
    ../../../../../../Source/Library/lwIP/src/netif/: etharp.c ethernetif.c loopif.c slipif.c
  group Source/Library/lwIP/src/netif/ppp
    ../../../../../../Source/Library/lwIP/src/netif/ppp/: auth.c auth.h chap.c chap.h chpms.c chpms.h fsm.c fsm.h ipcp.c ipcp.h lcp.c lcp.h magic.c magic.h md5.c md5.h pap.c pap.h ppp.c ppp.h ppp_oe.c pppdebug.h randm.c randm.h vj.c vj.h vjbsdhdr.h
  group Source/Library/lwip_2.0.x
    ../../../../../../Source/Library/lwip_2.0.x/: emac.h uEZEMAC_lwIP.c
  group Source/Library/lwip_2.0.x/src/api
    ../../../../../../Source/Library/lwip_2.0.x/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Source/Library/lwip_2.0.x/src/apps/snmp
    ../../../../../../Source/Library/lwip_2.0.x/src/apps/snmp/: snmp_asn1.c snmp_asn1.h snmp_core.c snmp_core_priv.h snmp_mib2.c snmp_mib2_icmp.c snmp_mib2_interfaces.c snmp_mib2_ip.c snmp_mib2_snmp.c snmp_mib2_system.c snmp_mib2_tcp.c snmp_mib2_udp.c snmp_msg.c snmp_msg.h snmp_netconn.c snmp_pbuf_stream.c snmp_pbuf_stream.h snmp_raw.c snmp_scalar.c snmp_snmpv2_framework.c snmp_snmpv2_usm.c snmp_table.c snmp_threadsync.c snmp_traps.c snmpv3.c snmpv3_mbedtls.c snmpv3_priv.h
  group Source/Library/lwip_2.0.x/src/core
    ../../../../../../Source/Library/lwip_2.0.x/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Source/Library/lwip_2.0.x/src/core/ipv4
    ../../../../../../Source/Library/lwip_2.0.x/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Source/Library/lwip_2.0.x/src/core/ipv6
    ../../../../../../Source/Library/lwip_2.0.x/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group Source/Library/lwip_2.0.x/src/include/lwip
    ../../../../../../Source/Library/lwip_2.0.x/src/include/lwip/: altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group Source/Library/lwip_2.0.x/src/include/lwip/apps
    ../../../../../../Source/Library/lwip_2.0.x/src/include/lwip/apps/: fs.h httpd.h httpd_opts.h lwiperf.h mdns.h mdns_opts.h mdns_priv.h mqtt.h mqtt_opts.h netbiosns.h netbiosns_opts.h snmp.h snmp_core.h snmp_mib2.h snmp_opts.h snmp_scalar.h snmp_table.h snmp_threadsync.h snmpv3.h sntp.h sntp_opts.h tftp_opts.h tftp_server.h
  group Source/Library/lwip_2.0.x/src/include/lwip/priv
    ../../../../../../Source/Library/lwip_2.0.x/src/include/lwip/priv/: api_msg.h memp_priv.h memp_std.h nd6_priv.h tcp_priv.h tcpip_priv.h
  group Source/Library/lwip_2.0.x/src/include/lwip/prot
    ../../../../../../Source/Library/lwip_2.0.x/src/include/lwip/prot/: autoip.h dhcp.h dns.h etharp.h ethernet.h icmp.h icmp6.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group Source/Library/lwip_2.0.x/src/include/netif
    ../../../../../../Source/Library/lwip_2.0.x/src/include/netif/: etharp.h ethernet.h lowpan6.h lowpan6_opts.h slipif.h
  group Source/Library/lwip_2.0.x/src/include/netif/ppp
    ../../../../../../Source/Library/lwip_2.0.x/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group Source/Library/lwip_2.0.x/src/include/posix
    ../../../../../../Source/Library/lwip_2.0.x/src/include/posix/: errno.h netdb.h
  group Source/Library/lwip_2.0.x/src/include/posix/sys
    ../../../../../../Source/Library/lwip_2.0.x/src/include/posix/sys/: socket.h
  group Source/Library/lwip_2.0.x/src/netif
    ../../../../../../Source/Library/lwip_2.0.x/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c ethernetif.c ethernetif_org.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group Source/Library/lwip_2.0.x/src/netif/ppp
    ../../../../../../Source/Library/lwip_2.0.x/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group Source/Library/lwip_2.0.x/system/arch
    ../../../../../../Source/Library/lwip_2.0.x/system/arch/: bpstruct.h cc.h cpu.h epstruct.h init.h lib.h perf.h sys_arch.h
  group Source/Library/lwip_2.0.x/system/OS
    ../../../../../../Source/Library/lwip_2.0.x/system/OS/: sys_arch.c
  group Source/Library/lwip_2.0.x/test/sockets
    ../../../../../../Source/Library/lwip_2.0.x/test/sockets/: sockets_stresstest.c sockets_stresstest.h
  group Source/Library/Memory/MemoryTest
    ../../../../../../Source/Library/Memory/MemoryTest/: MemoryTest.c MemoryTest.h
  group Source/Library/Network/GainSpan/CmdLib
    ../../../../../../Source/Library/Network/GainSpan/CmdLib/: AtCmdLib.c AtCmdLib.h GainSpan_CmdLib.c GainSpan_CmdLib.h GainSpan_SPI.c GainSpan_SPI.h
  group Source/Library/Network/PHY/MDIOBitBang
    ../../../../../../Source/Library/Network/PHY/MDIOBitBang/: MDIOBitBang.c MDIOBitBang.h
  group Source/Library/Parser/IntelHexParser
    ../../../../../../Source/Library/Parser/IntelHexParser/: IntelHexParser.c IntelHexParser.h
  group Source/Library/ScreenSaver
    ../../../../../../Source/Library/ScreenSaver/: BouncingLogoSS.c BouncingLogoSS.h
  group Source/Library/SEGGER/RTT
    ../../../../../../Source/Library/SEGGER/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_ASM_ARMv7M.S SEGGER_RTT_Conf.h SEGGER_RTT_Printf.c SEGGER_RTT_Syscalls_IAR.c
  group Source/Library/SEGGER/SystemView
    ../../../../../../Source/Library/SEGGER/SystemView/: SEGGER.h SEGGER_SYSVIEW.c SEGGER_SYSVIEW.h SEGGER_SYSVIEW_Conf.h SEGGER_SYSVIEW_ConfDefaults.h SEGGER_SYSVIEW_FreeRTOS.c SEGGER_SYSVIEW_FreeRTOS.h SEGGER_SYSVIEW_Int.h
  group Source/Library/StreamIO/StdInOut
    ../../../../../../Source/Library/StreamIO/StdInOut/: StdInOut.c StdInOut.h
  group Source/Library/StreamIO/StdInOut/IAR
    ../../../../../../Source/Library/StreamIO/StdInOut/IAR/: StdInOut_IAR.c
  group Source/Library/Tests/ALS/Vishay/VCNL4010
    ../../../../../../Source/Library/Tests/ALS/Vishay/VCNL4010/: TestVCNL4010.c TestVCNL4010.h
  group Source/Library/uEZFailure
    ../../../../../../Source/Library/uEZFailure/: FatalError.c FatalError.h uEZFailure.c uEZFailure.h
  group Source/Library/USBDevice/LPCUSBLib/MassStorage
    ../../../../../../Source/Library/USBDevice/LPCUSBLib/MassStorage/: USBMSDrive.c USBMSDrive.h
  group Source/Library/USBDevice/LPCUSBLib/VirtualComm
    ../../../../../../Source/Library/USBDevice/LPCUSBLib/VirtualComm/: VirtualComm.c VirtualComm.h
  group Source/Library/Web/BasicWeb
    ../../../../../../Source/Library/Web/BasicWeb/: BasicWEB.c BasicWEB.h
  group Source/Library/Web/HTTPServer
    ../../../../../../Source/Library/Web/HTTPServer/: HTTPServer.c HTTPServer.h
  group Source/Platform/emWin
    ../../../../../../Source/Platform/emWin/: GUI_X_uEZ.c
  group Source/Platform/emWin/Config
    ../../../../../../Source/Platform/emWin/Config/: GUIConf.c GUIConf.h LCDConf.c LCDConf.h
  group Source/Processor/NXP/LPC43xx
    ../../../../../../Source/Processor/NXP/LPC43xx/: LPC43xx_ADCBank.c LPC43xx_ADCBank.h LPC43xx_DAC.c LPC43xx_DAC.h LPC43xx_EMAC.c LPC43xx_EMAC.h LPC43xx_ExternalBus.c LPC43xx_ExternalBus.h LPC43xx_GPDMA.c LPC43xx_GPDMA.h LPC43xx_GPIO.c LPC43xx_GPIO.h LPC43xx_HALInit.c LPC43xx_I2C.c LPC43xx_I2C.h LPC43xx_I2S.c LPC43xx_I2S.h LPC43xx_Interrupt.c LPC43xx_LCDController.c LPC43xx_LCDController.h LPC43xx_PLL.c LPC43xx_PLL.h LPC43xx_PWM.c LPC43xx_PWM.h LPC43xx_RTC.c LPC43xx_RTC.h LPC43xx_SD_MMC.c LPC43xx_SDRAM.c LPC43xx_SDRAM.h LPC43xx_Serial.c LPC43xx_Serial.h LPC43xx_SSP.c LPC43xx_SSP.h LPC43xx_Timer.c LPC43xx_Timer.h LPC43xx_UtilityFuncs.c LPC43xx_UtilityFuncs.h LPC43xx_Watchdog.c LPC43xx_Watchdog.h uEZProcessor_LPC43xx.h
  group Source/Processor/NXP/LPC43xx/CMSIS
    ../../../../../../Source/Processor/NXP/LPC43xx/Common/include/CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0.h core_cm0plus.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h LPC43xx.h system_LPC43xx.c system_LPC43xx.h
  group Source/Processor/NXP/LPC43xx/IAR
    ../../../../../../Source/Processor/NXP/LPC43xx/IAR/: startup_LPC43xx.s
  group Source/RTOS
    ../../../../../../Source/RTOS/: uEZRTOS.c
  group Source/RTOS/FreeRTOS
    ../../../../../../Source/RTOS/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Source/RTOS/FreeRTOS/include
    ../../../../../../Source/RTOS/FreeRTOS/include/: atomic.h croutine.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
  group Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F
    ../../../../../../Source/RTOS/FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group Source/RTOS/FreeRTOS/portable/MemMang
    ../../../../../../Source/RTOS/FreeRTOS/portable/MemMang/: heap_1.c heap_2.c heap_3.c heap_4.c heap_5.c
  group Source/RTOS/FreeRTOS-Plus/FreeRTOS-Plus-Trace
    ../../../../../../Source/RTOS/FreeRTOS-Plus/FreeRTOS-Plus-Trace/: trcBase.c trcHardwarePort.c trcKernel.c trcKernelPort.c trcUser.c
  group Source/RTOS/FreeRTOS-Plus/FreeRTOS-Plus-Trace/Include
    ../../../../../../Source/RTOS/FreeRTOS-Plus/FreeRTOS-Plus-Trace/Include/: trcBase.h trcConfig.h trcHardwarePort.h trcKernel.h trcKernelHooks.h trcKernelPort.h trcTypes.h trcUser.h
  group Source/uEZSystem
    ../../../../../../Source/uEZSystem/: HAL.c uEZAccelerometer.c uEZADC.c uEZAudioAmp.c uEZAudioMixer.c uEZBSPInit.c uEZButton.c uEZCharDisplay.c uEZCRC.c uEZDAC.c uEZDeviceTable.c uEZEEPROM.c uEZEINT.c uEZFile.c uEZFlash.c uEZGPIO.c uEZHandles.c uEZHandles.h uEZHID.c uEZI2C.c uEZINI.c uEZInit.c uEZKeypad.c uEZLCD.c uEZLEDBank.c uEZMemory.c uEZNetwork.c uEZPWM.c uEZRandom.c uEZResourceCache.c uEZSPI.c uEZStream.c uEZTemperature.c uEZTimeDate.c uEZTimer.c uEZToneGenerator.c uEZTS.c uEZWatchdog.c uEZWAVFile.c
