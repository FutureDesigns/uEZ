<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\uEZ_NXP_LPC2478_FreeRTOS_IAR6.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>uEZ_NXP_LPC2478_FreeRTOS_IAR6</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>uEZ_NXP_LPC2478_FreeRTOS_IAR6</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>uEZ_NXP_LPC2478_FreeRTOS_IAR6</project>
        <configuration>THUMB Debug</configuration>
      </member>
      <member>
        <project>uEZ_NXP_LPC2478_FreeRTOS_IAR6</project>
        <configuration>THUMB Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


